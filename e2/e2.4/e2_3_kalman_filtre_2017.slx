simulink model "e2_3_kalman_filtre_2017"  (R2018b)
settings: Solver=FixedStepAuto  StartTime=0.0  StopTime=30  FixedStep=fixed_step_size  RelTol=1e-3
StopFcn:
  | if AUTOLAND
  | %1_2
  | land1 = rospublisher('/tello1/land','std_msgs/Empty');
  | msg=rosmessage(land1);
  | send(land1,msg);
  | land2 = rospublisher('/tello2/land','std_msgs/Empty');
  | msg=rosmessage(land2);
  | send(land2,msg);
  | %3_4
  | land3 = rospublisher('/tello3/land','std_msgs/Empty');
  | msg=rosmessage(land3);
  | send(land3,msg);
  | land4 = rospublisher('/tello4/land','std_msgs/Empty');
  | msg=rosmessage(land4);
  | send(land4,msg);
  | %5_6
  | land5 = rospublisher('/tello5/land','std_msgs/Empty');
  | msg=rosmessage(land5);
  | send(land5,msg);
  | land6= rospublisher('/tello6/land','std_msgs/Empty');
  | msg=rosmessage(land6);
  | send(land6,msg);
  | %7_8
  | land7 = rospublisher('/tello7/land','std_msgs/Empty');
  | msg=rosmessage(land7);
  | send(land7,msg);
  | land8 = rospublisher('/tello8/land','std_msgs/Empty');
  | msg=rosmessage(land8);
  | send(land8,msg);
  | end
  | 
  | generate_cifer_datapack
  | 
  | if TELLO_PLOT
  | tello8_plot
  | end
values from neighbouring files (symbols this model uses):
  a = XMAX    (= 0.8)    [start_tello.m]
  b = YMAX    (= 1.2)    [start_tello.m]
  battery_threshold = 15    [start_tello.m]
  bb = (ZMIN*YMAX - ZMAX*YMIN)/(YMAX - YMIN)    (= -1.05)    [start_tello.m]
  fcnCmdMag = 1    [start.m]
  fcnNumber = 4    [start.m]
  fcnSinFreq = 50.0    (= 50)    [start.m]
  high_time = 5    [start.m]
  k = (ZMAX - ZMIN)/(YMAX - YMIN)    (= 0.458333333333)    [start_tello.m]
  omega = 1.0    (= 1)    [start.m]    (also in start_tello.m = 0.3)
  PARAM_C1 = 4.0    (= 4)    [start.m]
  PARAM_C2 = 0.0187    [start.m]
  PARAM_isNoiseOn = false    [start.m]
  PARAM_T_rec = ceil(5*2*pi/PARAM_w_min)    [start.m]
  PARAM_time_end = PARAM_time_start + 20    (= 23)    [start.m]
  PARAM_time_start = 3    [start.m]
  PARAM_w_max = 12    [start.m]
  PARAM_w_min = 0.5    [start.m]
  R = 1.0    (= 1)    [start.m]    (also in start_tello.m)
  sim_end_time = 15*act_end + 4    (= 475.238898038)    [start_tello.m]
  step_period = zero1_time+high_time+zero2_time+low_time    (= 18)    [start.m]
  tb2 = tb    (= 2.7)    [start_tello.m]
  tb3 = tb*2    (= 5.4)    [start_tello.m]
  tb4 = tb*3    (= 8.1)    [start_tello.m]
  tb5 = tb*4    (= 10.8)    [start_tello.m]
  tb6 = tb*5    (= 13.5)    [start_tello.m]
  tb7 = tb*6    (= 16.2)    [start_tello.m]
  tb8 = tb*7    (= 18.9)    [start_tello.m]
  TELLO1_NUM = uint8(1)    [start_tello.m]
  TELLO2_NUM = uint8(2)    [start_tello.m]
  TELLO3_NUM = uint8(3)    [start_tello.m]
  TELLO4_NUM = uint8(4)    [start_tello.m]
  TELLO5_NUM = uint8(5)    [start_tello.m]
  TELLO6_NUM = uint8(6)    [start_tello.m]
  TELLO7_NUM = uint8(7)    [start_tello.m]
  TELLO8_NUM = uint8(8)    [start_tello.m]
  UAV_NUM = 0    [start_tello.m]
  w1 = 0.4    [start_tello.m]
  w2 = 0.2    [start_tello.m]
  z_d_for_land = -0.2    [start_tello.m]
  zero1_time = 3    [start.m]
  zero2_time = 5    [start.m]
  zero3_time = 5    [start.m]
undefined symbols (not defined in the file or in its folder): DiscIntNeverNeededParam, sigbuilder_block
libraries: simulink x45, etargetslib x24, dspnetwork x24, sharedtransform x8, aerolibanimutils x1
(part 2 of 4)

== system e2_3_kalman_filtre_2017/CMD/CMD7 ==
  "clock " : Inport
  Constant3 : Constant  Value=0
  Manual Switch2 : ManualSwitch
  Sine Wave2 : Sin  Amplitude=0.3  Frequency=1.0
  Slider Gain3 : simulink/Math Operations/Slider Gain  gain=1  low=0  high=2
  Subsystem : Subsystem
  x_d : Outport
  y_d : Outport  Port=2
  z_d : Outport  Port=3
  yaw_d : Outport  Port=4
  wires:
  Subsystem/1("x ") -> x_d/1
  Manual Switch2/1 -> Slider Gain3/1
  Slider Gain3/1 -> yaw_d/1
  Sine Wave2/1 -> Manual Switch2/2
  Constant3/1 -> Manual Switch2/1
  Subsystem/3(z) -> z_d/1
  "clock "/1 -> Subsystem/1(clock)
  Subsystem/2(y) -> y_d/1

== system e2_3_kalman_filtre_2017/CMD/CMD8 ==
  "clock " : Inport
  Constant3 : Constant  Value=0
  Manual Switch2 : ManualSwitch
  Sine Wave2 : Sin  Amplitude=0.3  Frequency=1.0
  Slider Gain3 : simulink/Math Operations/Slider Gain  gain=1  low=0  high=2
  Subsystem : Subsystem
  x_d : Outport
  y_d : Outport  Port=2
  z_d : Outport  Port=3
  yaw_d : Outport  Port=4
  wires:
  Subsystem/1("x ") -> x_d/1
  Manual Switch2/1 -> Slider Gain3/1
  Slider Gain3/1 -> yaw_d/1
  Sine Wave2/1 -> Manual Switch2/2
  Constant3/1 -> Manual Switch2/1
  Subsystem/3(z) -> z_d/1
  "clock "/1 -> Subsystem/1(clock)
  Subsystem/2(y) -> y_d/1

== system e2_3_kalman_filtre_2017/control system/Baseline Controller Basic ==
  X_e : Inport
  Y_e : Inport  Port=2
  " Z_e " : Inport  Port=3
  Yaw_e : Inport  Port=4
  " V_x" : Inport  Port=5
  V_y : Inport  Port=6
  V_z : Inport  Port=7
  x_d : Inport  Port=8
  y_d : Inport  Port=9
  Z_d : Inport  Port=10
  Yaw_d : Inport  Port=11
  Constant : Constant  Value=0
  Controller X : Subsystem
  Controller Y : Subsystem
  Decoupling : Subsystem
  Heading controller : Subsystem
  "Height controller " : Subsystem
  Scope : Scope  NumInputPorts=11
  Scope1 : Scope  NumInputPorts=4
  Scope2 : Scope
  ux : Outport
  uy : Outport  Port=2
  Z_velocity_d. [-1,1] : Outport  Port=3
  yaw_rate_d [-1,1] : Outport  Port=4
  wires:
  x_d/1 -> Scope2/1, Controller X/2(X_d (m)), Scope/2
  Z_d/1 -> Scope/9, "Height controller "/1(Z_d. (m))
  Y_e/1 -> Controller Y/1(Y_e (m)), Scope/4
  Yaw_d/1 -> Scope/8, Heading controller/2(yaw_d. (rad))
  "Height controller "/1(Z_velocity_d (m/s)) -> Scope1/4, Z_velocity_d. [-1,1]/1
  X_e/1 -> Scope/1, Controller X/1(X_e (m))
  " Z_e "/1 -> Scope/10, "Height controller "/2(Z_e (m))
  Heading controller/1(yaw_rate_d. (rad/s)) -> yaw_rate_d [-1,1]/1, Scope1/3
  Yaw_e/1 -> Scope/7, Heading controller/1(yaw_e (rad))  "yaw"
  V_z/1 -> Scope/11, "Height controller "/3(V_z)
  y_d/1 -> Scope/5, Controller Y/2(Y_d (m))
  Decoupling/1(D_Ux) -> Scope1/1, ux/1
  Decoupling/2(D_Uy) -> Scope1/2, uy/1
  Controller Y/1(uy) -> Decoupling/3(Uy)
  Controller X/1(U_x) -> Decoupling/1(Ux)
  " V_x"/1 -> Scope/3, Controller X/3(V_x_e)
  V_y/1 -> Scope/6, Controller Y/3(V_y_e)
  Constant/1 -> Decoupling/2(yaw_e)

== system e2_3_kalman_filtre_2017/control system/Baseline Controller2 ==
  X_e : Inport
  Y_e : Inport  Port=2
  " Z_e " : Inport  Port=3
  Yaw_e : Inport  Port=4
  " V_x" : Inport  Port=5
  V_y : Inport  Port=6
  "V_z " : Inport  Port=7
  x_d : Inport  Port=8
  y_d : Inport  Port=9
  Z_d : Inport  Port=10
  Yaw_d : Inport  Port=11
  Constant : Constant  Value=omega*R*2
  Demux : Demux  Outputs=2
  Heading controller : Subsystem
  "Height controller " : Subsystem
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  Position controller : Subsystem
  ux : Outport
  uy : Outport  Port=2
  Z_velocity_d. [-1,1] : Outport  Port=3
  yaw_rate_d [-1,1] : Outport  Port=4
  wires:
  Position controller/1(uxy) -> MATLAB Function/1(u)
  "V_z "/1 -> "Height controller "/3(V_z)
  Yaw_e/1 -> Position controller/5(Yaw_e (rad)), Heading controller/1(yaw_e (rad))  "yaw"
  y_d/1 -> Position controller/4(Y_d (m))
  x_d/1 -> Position controller/3(X_d (m))
  Z_d/1 -> "Height controller "/1(Z_d. (m))
  Constant/1 -> MATLAB Function/2(a)
  Demux/2 -> uy/1
  Demux/1 -> ux/1
  MATLAB Function/1(y) -> Demux/1
  Yaw_d/1 -> Heading controller/2(yaw_d. (rad))
  Y_e/1 -> Position controller/2(Y_e (m))
  X_e/1 -> Position controller/1(X_e (m))
  Heading controller/1(yaw_rate_d. (rad/s)) -> yaw_rate_d [-1,1]/1
  "Height controller "/1(Z_velocity_d (m/s)) -> Z_velocity_d. [-1,1]/1
  " Z_e "/1 -> "Height controller "/2(Z_e (m))

== system e2_3_kalman_filtre_2017/control system/Baseline Controller3 ==
  X_e : Inport
  Y_e : Inport  Port=2
  " Z_e " : Inport  Port=3
  Yaw_e : Inport  Port=4
  " V_x" : Inport  Port=5
  V_y : Inport  Port=6
  "V_z " : Inport  Port=7
  x_d : Inport  Port=8
  y_d : Inport  Port=9
  Z_d : Inport  Port=10
  Yaw_d : Inport  Port=11
  Constant : Constant  Value=omega*R*2
  Demux : Demux  Outputs=2
  Heading controller : Subsystem
  "Height controller " : Subsystem
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  Position controller : Subsystem
  ux : Outport
  uy : Outport  Port=2
  Z_velocity_d. [-1,1] : Outport  Port=3
  yaw_rate_d [-1,1] : Outport  Port=4
  wires:
  " Z_e "/1 -> "Height controller "/2(Z_e (m))
  "Height controller "/1(Z_velocity_d (m/s)) -> Z_velocity_d. [-1,1]/1
  Heading controller/1(yaw_rate_d. (rad/s)) -> yaw_rate_d [-1,1]/1
  X_e/1 -> Position controller/1(X_e (m))
  Y_e/1 -> Position controller/2(Y_e (m))
  Yaw_d/1 -> Heading controller/2(yaw_d. (rad))
  MATLAB Function/1(y) -> Demux/1
  Demux/1 -> ux/1
  Demux/2 -> uy/1
  Constant/1 -> MATLAB Function/2(a)
  Z_d/1 -> "Height controller "/1(Z_d. (m))
  x_d/1 -> Position controller/3(X_d (m))
  y_d/1 -> Position controller/4(Y_d (m))
  Yaw_e/1 -> Heading controller/1(yaw_e (rad)), Position controller/5(Yaw_e (rad))  "yaw"
  "V_z "/1 -> "Height controller "/3(V_z)
  Position controller/1(uxy) -> MATLAB Function/1(u)

== system e2_3_kalman_filtre_2017/control system/Baseline Controller4 ==
  X_e : Inport
  Y_e : Inport  Port=2
  " Z_e " : Inport  Port=3
  Yaw_e : Inport  Port=4
  " V_x" : Inport  Port=5
  V_y : Inport  Port=6
  "V_z " : Inport  Port=7
  x_d : Inport  Port=8
  y_d : Inport  Port=9
  Z_d : Inport  Port=10
  Yaw_d : Inport  Port=11
  Constant : Constant  Value=omega*R*2
  Demux : Demux  Outputs=2
  Heading controller : Subsystem
  "Height controller " : Subsystem
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  Position controller : Subsystem
  ux : Outport
  uy : Outport  Port=2
  Z_velocity_d. [-1,1] : Outport  Port=3
  yaw_rate_d [-1,1] : Outport  Port=4
  wires:
  Position controller/1(uxy) -> MATLAB Function/1(u)
  "V_z "/1 -> "Height controller "/3(V_z)
  Yaw_e/1 -> Position controller/5(Yaw_e (rad)), Heading controller/1(yaw_e (rad))  "yaw"
  y_d/1 -> Position controller/4(Y_d (m))
  x_d/1 -> Position controller/3(X_d (m))
  Z_d/1 -> "Height controller "/1(Z_d. (m))
  Constant/1 -> MATLAB Function/2(a)
  Demux/2 -> uy/1
  Demux/1 -> ux/1
  MATLAB Function/1(y) -> Demux/1
  Yaw_d/1 -> Heading controller/2(yaw_d. (rad))
  Y_e/1 -> Position controller/2(Y_e (m))
  X_e/1 -> Position controller/1(X_e (m))
  Heading controller/1(yaw_rate_d. (rad/s)) -> yaw_rate_d [-1,1]/1
  "Height controller "/1(Z_velocity_d (m/s)) -> Z_velocity_d. [-1,1]/1
  " Z_e "/1 -> "Height controller "/2(Z_e (m))

== system e2_3_kalman_filtre_2017/control system/Baseline Controller5 ==
  X_e : Inport
  Y_e : Inport  Port=2
  " Z_e " : Inport  Port=3
  Yaw_e : Inport  Port=4
  " V_x" : Inport  Port=5
  V_y : Inport  Port=6
  "V_z " : Inport  Port=7
  x_d : Inport  Port=8
  y_d : Inport  Port=9
  Z_d : Inport  Port=10
  Yaw_d : Inport  Port=11
  Constant : Constant  Value=omega*R*2
  Demux : Demux  Outputs=2
  Heading controller : Subsystem
  "Height controller " : Subsystem
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  Position controller : Subsystem
  ux : Outport
  uy : Outport  Port=2
  Z_velocity_d. [-1,1] : Outport  Port=3
  yaw_rate_d [-1,1] : Outport  Port=4
  wires:
  " Z_e "/1 -> "Height controller "/2(Z_e (m))
  "Height controller "/1(Z_velocity_d (m/s)) -> Z_velocity_d. [-1,1]/1
  Heading controller/1(yaw_rate_d. (rad/s)) -> yaw_rate_d [-1,1]/1
  X_e/1 -> Position controller/1(X_e (m))
  Y_e/1 -> Position controller/2(Y_e (m))
  Yaw_d/1 -> Heading controller/2(yaw_d. (rad))
  MATLAB Function/1(y) -> Demux/1
  Demux/1 -> ux/1
  Demux/2 -> uy/1
  Constant/1 -> MATLAB Function/2(a)
  Z_d/1 -> "Height controller "/1(Z_d. (m))
  x_d/1 -> Position controller/3(X_d (m))
  y_d/1 -> Position controller/4(Y_d (m))
  Yaw_e/1 -> Heading controller/1(yaw_e (rad)), Position controller/5(Yaw_e (rad))  "yaw"
  "V_z "/1 -> "Height controller "/3(V_z)
  Position controller/1(uxy) -> MATLAB Function/1(u)

== system e2_3_kalman_filtre_2017/control system/Baseline Controller6 ==
  X_e : Inport
  Y_e : Inport  Port=2
  " Z_e " : Inport  Port=3
  Yaw_e : Inport  Port=4
  " V_x" : Inport  Port=5
  V_y : Inport  Port=6
  "V_z " : Inport  Port=7
  x_d : Inport  Port=8
  y_d : Inport  Port=9
  Z_d : Inport  Port=10
  Yaw_d : Inport  Port=11
  Constant : Constant  Value=omega*R*2
  Demux : Demux  Outputs=2
  Heading controller : Subsystem
  "Height controller " : Subsystem
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  Position controller : Subsystem
  ux : Outport
  uy : Outport  Port=2
  Z_velocity_d. [-1,1] : Outport  Port=3
  yaw_rate_d [-1,1] : Outport  Port=4
  wires:
  Position controller/1(uxy) -> MATLAB Function/1(u)
  "V_z "/1 -> "Height controller "/3(V_z)
  Yaw_e/1 -> Position controller/5(Yaw_e (rad)), Heading controller/1(yaw_e (rad))  "yaw"
  y_d/1 -> Position controller/4(Y_d (m))
  x_d/1 -> Position controller/3(X_d (m))
  Z_d/1 -> "Height controller "/1(Z_d. (m))
  Constant/1 -> MATLAB Function/2(a)
  Demux/2 -> uy/1
  Demux/1 -> ux/1
  MATLAB Function/1(y) -> Demux/1
  Yaw_d/1 -> Heading controller/2(yaw_d. (rad))
  Y_e/1 -> Position controller/2(Y_e (m))
  X_e/1 -> Position controller/1(X_e (m))
  Heading controller/1(yaw_rate_d. (rad/s)) -> yaw_rate_d [-1,1]/1
  "Height controller "/1(Z_velocity_d (m/s)) -> Z_velocity_d. [-1,1]/1
  " Z_e "/1 -> "Height controller "/2(Z_e (m))

== system e2_3_kalman_filtre_2017/control system/Baseline Controller7 ==
  X_e : Inport
  Y_e : Inport  Port=2
  " Z_e " : Inport  Port=3
  Yaw_e : Inport  Port=4
  " V_x" : Inport  Port=5
  V_y : Inport  Port=6
  "V_z " : Inport  Port=7
  x_d : Inport  Port=8
  y_d : Inport  Port=9
  Z_d : Inport  Port=10
  Yaw_d : Inport  Port=11
  Constant : Constant  Value=omega*R*2
  Demux : Demux  Outputs=2
  Heading controller : Subsystem
  "Height controller " : Subsystem
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  Position controller : Subsystem
  ux : Outport
  uy : Outport  Port=2
  Z_velocity_d. [-1,1] : Outport  Port=3
  yaw_rate_d [-1,1] : Outport  Port=4
  wires:
  " Z_e "/1 -> "Height controller "/2(Z_e (m))
  "Height controller "/1(Z_velocity_d (m/s)) -> Z_velocity_d. [-1,1]/1
  Heading controller/1(yaw_rate_d. (rad/s)) -> yaw_rate_d [-1,1]/1
  X_e/1 -> Position controller/1(X_e (m))
  Y_e/1 -> Position controller/2(Y_e (m))
  Yaw_d/1 -> Heading controller/2(yaw_d. (rad))
  MATLAB Function/1(y) -> Demux/1
  Demux/1 -> ux/1
  Demux/2 -> uy/1
  Constant/1 -> MATLAB Function/2(a)
  Z_d/1 -> "Height controller "/1(Z_d. (m))
  x_d/1 -> Position controller/3(X_d (m))
  y_d/1 -> Position controller/4(Y_d (m))
  Yaw_e/1 -> Heading controller/1(yaw_e (rad)), Position controller/5(Yaw_e (rad))  "yaw"
  "V_z "/1 -> "Height controller "/3(V_z)
  Position controller/1(uxy) -> MATLAB Function/1(u)

== system e2_3_kalman_filtre_2017/control system/Baseline Controller8 ==
  X_e : Inport
  Y_e : Inport  Port=2
  " Z_e " : Inport  Port=3
  Yaw_e : Inport  Port=4
  " V_x" : Inport  Port=5
  V_y : Inport  Port=6
  "V_z " : Inport  Port=7
  x_d : Inport  Port=8
  y_d : Inport  Port=9
  Z_d : Inport  Port=10
  Yaw_d : Inport  Port=11
  Constant : Constant  Value=omega*R*2
  Demux : Demux  Outputs=2
  Heading controller : Subsystem
  "Height controller " : Subsystem
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  Position controller : Subsystem
  ux : Outport
  uy : Outport  Port=2
  Z_velocity_d. [-1,1] : Outport  Port=3
  yaw_rate_d [-1,1] : Outport  Port=4
  wires:
  Position controller/1(uxy) -> MATLAB Function/1(u)
  "V_z "/1 -> "Height controller "/3(V_z)
  Yaw_e/1 -> Position controller/5(Yaw_e (rad)), Heading controller/1(yaw_e (rad))  "yaw"
  y_d/1 -> Position controller/4(Y_d (m))
  x_d/1 -> Position controller/3(X_d (m))
  Z_d/1 -> "Height controller "/1(Z_d. (m))
  Constant/1 -> MATLAB Function/2(a)
  Demux/2 -> uy/1
  Demux/1 -> ux/1
  MATLAB Function/1(y) -> Demux/1
  Yaw_d/1 -> Heading controller/2(yaw_d. (rad))
  Y_e/1 -> Position controller/2(Y_e (m))
  X_e/1 -> Position controller/1(X_e (m))
  Heading controller/1(yaw_rate_d. (rad/s)) -> yaw_rate_d [-1,1]/1
  "Height controller "/1(Z_velocity_d (m/s)) -> Z_velocity_d. [-1,1]/1
  " Z_e "/1 -> "Height controller "/2(Z_e (m))

== system e2_3_kalman_filtre_2017/control system/Kalman_Filtre ==
  Pos_Real : Inport
  Velocity_Real : Inport  Port=2
  Bus Creator12 : BusCreator  Inputs=3
  Demux : Demux
  Demux1 : Demux  Outputs=3
  Kalman Filtre H : Subsystem
  Kalman Filtre Psi : Subsystem
  Kalman Filtre X : Subsystem
  Kalman Filtre Y : Subsystem
  Velocity_Feedback : Outport
  wires:
  Pos_Real/1 -> Demux/1
  Demux/3 -> Kalman Filtre H/1(The system output: Position)
  Kalman Filtre X/1(Out velocity feedback) -> Bus Creator12/1
  Demux/1 -> Kalman Filtre X/1(The system output: Position)
  Demux/4 -> Kalman Filtre Psi/1(The system output: Position)
  Kalman Filtre H/1(Out velocity feedback) -> Bus Creator12/3
  Kalman Filtre Y/1(Out velocity feedback) -> Bus Creator12/2
  Velocity_Real/1 -> Demux1/1
  Bus Creator12/1 -> Velocity_Feedback/1
  Demux1/1 -> Kalman Filtre X/2(real_vx)
  Demux/2 -> Kalman Filtre Y/1(The system output: Position)
  Demux1/3 -> Kalman Filtre H/2(real_vz)
  Demux1/2 -> Kalman Filtre Y/2(real_vy)

== system e2_3_kalman_filtre_2017/get_pos/logger ==
  tello1_states : Inport
  Bus Selector1 : BusSelector  OutputSignals=x1,y1,z1,yaw1
  Bus Selector2 : BusSelector  OutputSignals=vx1,vy1,vz1
  To Workspace : ToWorkspace  VariableName=posx  SampleTime=-1
  To Workspace1 : ToWorkspace  VariableName=posy  SampleTime=-1
  To Workspace2 : ToWorkspace  VariableName=posz  SampleTime=-1
  To Workspace3 : ToWorkspace  VariableName=yaw  SampleTime=-1
  To Workspace4 : ToWorkspace  VariableName=velx  SampleTime=-1
  To Workspace5 : ToWorkspace  VariableName=vely  SampleTime=-1
  To Workspace6 : ToWorkspace  VariableName=velz  SampleTime=-1
  wires:
  Bus Selector2/2 -> To Workspace5/1  "<vy1>"
  Bus Selector1/3 -> To Workspace2/1  "<z1>"
  Bus Selector2/1 -> To Workspace4/1  "<vx1>"
  Bus Selector1/4 -> To Workspace3/1  "<yaw1>"
  Bus Selector1/1 -> To Workspace/1  "<x1>"
  tello1_states/1 -> Bus Selector1/1, Bus Selector2/1
  Bus Selector1/2 -> To Workspace1/1  "<y1>"
  Bus Selector2/3 -> To Workspace6/1  "<vz1>"

== system e2_3_kalman_filtre_2017/send_ctrl_signal/Send Command 1 ==
  pos : Inport
  u : Inport  Port=2
  Bus Selector : BusSelector  OutputSignals=tello1_states.z1
  Bus Selector1 : BusSelector  OutputSignals=tello1.u_vx,tello1.u_vy,tello1.u_vz,tello1.u_rate_roll,tello1.u_rate_pitch,tello1.u_rate_yaw
  Byte Pack : etargetslib/Byte Pack  datatypes={'uint8','double','double','double','double','double','double'}  byteAlign=1
  Clock : Clock
  Compare To Constant : simulink/Logic and Bit Operations/Compare To Constant  relop=>=  const=0.1  OutDataTypeStr=boolean
  Compare To Constant1 : simulink/Logic and Bit Operations/Compare To Constant  relop=<  const=0  OutDataTypeStr=boolean
  Constant : Constant  Value=sim_end_time
  Constant1 : Constant  Value=0
  Constant2 : Constant  Value=TELLO1_NUM
  K : Gain  Gain=-1
  K1 : Gain
  K2 : Gain  Gain=-1
  Logical Operator : Logic  AllPortsSameDT=off  OutDataTypeStr=boolean
  Sum : Sum  Inputs=|-+
  Switch{1..3,12} (4 alike) : Switch  Criteria=u2 > Threshold  Threshold=0.001
  UDP Send7 : dspnetwork/UDP Send  remoteURL=UDP_SEND_IP  remotePort=TELLO1_SEND_PORT  localURL='0.0.0.0'  localPortSource=Automatically determine  localPort=-1  sampletime=-1  blockPlatform=[]  separateLengthPort=0
  wires:
  Constant1/1 -> Switch3/3, Switch2/3, Switch1/3, Switch12/3
  K/1 -> Byte Pack/3
  K1/1 -> Byte Pack/7
  Switch12/1 -> Byte Pack/2
  Switch1/1 -> K/1
  Bus Selector1/2 -> Switch1/1  "<u_vy>"
  Switch2/1 -> K2/1
  Bus Selector1/3 -> Switch2/1  "<u_vz>"
  Switch3/1 -> K1/1
  Logical Operator/1 -> Switch1/2, Switch12/2, Switch2/2, Switch3/2
  K2/1 -> Byte Pack/4
  Clock/1 -> Sum/1
  Constant/1 -> Sum/2
  Sum/1 -> Compare To Constant/1
  Compare To Constant/1 -> Logical Operator/2
  pos/1 -> Bus Selector/1
  Bus Selector/1 -> Compare To Constant1/1  "<z1>"
  u/1 -> Bus Selector1/1
  Bus Selector1/1 -> Switch12/1  "<u_vx>"
  Bus Selector1/6 -> Switch3/1  "<u_rate_yaw>"
  Bus Selector1/4 -> Byte Pack/5  "<u_rate_roll>"
  Bus Selector1/5 -> Byte Pack/6  "<u_rate_pitch>"
  Compare To Constant1/1 -> Logical Operator/1
  Byte Pack/1 -> UDP Send7/1
  Constant2/1 -> Byte Pack/1

== system e2_3_kalman_filtre_2017/send_ctrl_signal/Send Command 2 ==
  pos : Inport
  u : Inport  Port=2
  Bus Selector : BusSelector  OutputSignals=tello2_states.z2
  Bus Selector1 : BusSelector  OutputSignals=tello2.u_vx,tello2.u_vy,tello2.u_vz,tello2.u_rate_roll,tello2.u_rate_pitch,tello2.u_rate_yaw
  Byte Pack : etargetslib/Byte Pack  datatypes={'uint8','double','double','double','double','double','double'}  byteAlign=1
  Clock : Clock
  Compare To Constant : simulink/Logic and Bit Operations/Compare To Constant  relop=>=  const=0.1  OutDataTypeStr=boolean
  Compare To Constant1 : simulink/Logic and Bit Operations/Compare To Constant  relop=<  const=0  OutDataTypeStr=boolean
  Constant : Constant  Value=sim_end_time
  Constant1 : Constant  Value=0
  Constant2 : Constant  Value=TELLO2_NUM
  K : Gain  Gain=-1
  K1 : Gain
  K2 : Gain  Gain=-1
  Logical Operator : Logic  AllPortsSameDT=off  OutDataTypeStr=boolean
  Sum : Sum  Inputs=|-+
  Switch{1..3,12} (4 alike) : Switch  Criteria=u2 > Threshold  Threshold=0.001
  UDP Send7 : dspnetwork/UDP Send  remoteURL=UDP_SEND_IP  remotePort=TELLO2_SEND_PORT  localURL='0.0.0.0'  localPortSource=Automatically determine  localPort=-1  sampletime=-1  blockPlatform=[]  separateLengthPort=0
  wires:
  Constant1/1 -> Switch3/3, Switch2/3, Switch1/3, Switch12/3
  K/1 -> Byte Pack/3
  K1/1 -> Byte Pack/7
  Switch12/1 -> Byte Pack/2
  Switch1/1 -> K/1
  Bus Selector1/2 -> Switch1/1  "<u_vy>"
  Switch2/1 -> K2/1
  Bus Selector1/3 -> Switch2/1  "<u_vz>"
  Switch3/1 -> K1/1
  Logical Operator/1 -> Switch1/2, Switch12/2, Switch2/2, Switch3/2
  K2/1 -> Byte Pack/4
  Clock/1 -> Sum/1
  Constant/1 -> Sum/2
  Sum/1 -> Compare To Constant/1
  Compare To Constant/1 -> Logical Operator/2
  pos/1 -> Bus Selector/1
  Bus Selector/1 -> Compare To Constant1/1  "<z2>"
  u/1 -> Bus Selector1/1
  Bus Selector1/1 -> Switch12/1  "<u_vx>"
  Bus Selector1/6 -> Switch3/1  "<u_rate_yaw>"
  Bus Selector1/4 -> Byte Pack/5  "<u_rate_roll>"
  Bus Selector1/5 -> Byte Pack/6  "<u_rate_pitch>"
  Compare To Constant1/1 -> Logical Operator/1
  Byte Pack/1 -> UDP Send7/1
  Constant2/1 -> Byte Pack/1

== system e2_3_kalman_filtre_2017/send_ctrl_signal/Send Command 3 ==
  pos : Inport
  u : Inport  Port=2
  Bus Selector : BusSelector  OutputSignals=tello3_states.z3
  Bus Selector1 : BusSelector  OutputSignals=tello3.u_vx,tello3.u_vy,tello3.u_vz,tello3.u_rate_roll,tello3.u_rate_pitch,tello3.u_rate_yaw
  Byte Pack : etargetslib/Byte Pack  datatypes={'uint8','double','double','double','double','double','double'}  byteAlign=1
  Clock : Clock
  Compare To Constant : simulink/Logic and Bit Operations/Compare To Constant  relop=>=  const=0.1  OutDataTypeStr=boolean
  Compare To Constant1 : simulink/Logic and Bit Operations/Compare To Constant  relop=<  const=0  OutDataTypeStr=boolean
  Constant : Constant  Value=sim_end_time
  Constant1 : Constant  Value=0
  Constant2 : Constant  Value=TELLO3_NUM
  K : Gain  Gain=-1
  K1 : Gain
  K2 : Gain  Gain=-1
  Logical Operator : Logic  AllPortsSameDT=off  OutDataTypeStr=boolean
  Sum : Sum  Inputs=|-+
  Switch{1..3,12} (4 alike) : Switch  Criteria=u2 > Threshold  Threshold=0.001
  UDP Send7 : dspnetwork/UDP Send  remoteURL=UDP_SEND_IP  remotePort=TELLO3_SEND_PORT  localURL='0.0.0.0'  localPortSource=Automatically determine  localPort=-1  sampletime=-1  blockPlatform=[]  separateLengthPort=0
  wires:
  Constant1/1 -> Switch3/3, Switch2/3, Switch1/3, Switch12/3
  K/1 -> Byte Pack/3
  K1/1 -> Byte Pack/7
  Switch12/1 -> Byte Pack/2
  Switch1/1 -> K/1
  Bus Selector1/2 -> Switch1/1  "<u_vy>"
  Switch2/1 -> K2/1
  Bus Selector1/3 -> Switch2/1  "<u_vz>"
  Switch3/1 -> K1/1
  Logical Operator/1 -> Switch1/2, Switch12/2, Switch2/2, Switch3/2
  K2/1 -> Byte Pack/4
  Clock/1 -> Sum/1
  Constant/1 -> Sum/2
  Sum/1 -> Compare To Constant/1
  Compare To Constant/1 -> Logical Operator/2
  pos/1 -> Bus Selector/1
  Bus Selector/1 -> Compare To Constant1/1  "<z3>"
  u/1 -> Bus Selector1/1
  Bus Selector1/1 -> Switch12/1  "<u_vx>"
  Bus Selector1/6 -> Switch3/1  "<u_rate_yaw>"
  Bus Selector1/4 -> Byte Pack/5  "<u_rate_roll>"
  Bus Selector1/5 -> Byte Pack/6  "<u_rate_pitch>"
  Compare To Constant1/1 -> Logical Operator/1
  Byte Pack/1 -> UDP Send7/1
  Constant2/1 -> Byte Pack/1

== system e2_3_kalman_filtre_2017/send_ctrl_signal/Send Command 4 ==
  pos : Inport
  u : Inport  Port=2
  Bus Selector : BusSelector  OutputSignals=tello4_states.z4
  Bus Selector1 : BusSelector  OutputSignals=tello4.u_vx,tello4.u_vy,tello4.u_vz,tello4.u_rate_roll,tello4.u_rate_pitch,tello4.u_rate_yaw
  Byte Pack : etargetslib/Byte Pack  datatypes={'uint8','double','double','double','double','double','double'}  byteAlign=1
  Clock : Clock
  Compare To Constant : simulink/Logic and Bit Operations/Compare To Constant  relop=>=  const=0.1  OutDataTypeStr=boolean
  Compare To Constant1 : simulink/Logic and Bit Operations/Compare To Constant  relop=<  const=0  OutDataTypeStr=boolean
  Constant : Constant  Value=sim_end_time
  Constant1 : Constant  Value=0
  Constant2 : Constant  Value=TELLO4_NUM
  K : Gain  Gain=-1
  K1 : Gain
  K2 : Gain  Gain=-1
  Logical Operator : Logic  AllPortsSameDT=off  OutDataTypeStr=boolean
  Sum : Sum  Inputs=|-+
  Switch{1..3,12} (4 alike) : Switch  Criteria=u2 > Threshold  Threshold=0.001
  UDP Send7 : dspnetwork/UDP Send  remoteURL=UDP_SEND_IP  remotePort=TELLO4_SEND_PORT  localURL='0.0.0.0'  localPortSource=Automatically determine  localPort=-1  sampletime=-1  blockPlatform=[]  separateLengthPort=0
  wires:
  Constant1/1 -> Switch3/3, Switch2/3, Switch1/3, Switch12/3
  K/1 -> Byte Pack/3
  K1/1 -> Byte Pack/7
  Switch12/1 -> Byte Pack/2
  Switch1/1 -> K/1
  Bus Selector1/2 -> Switch1/1  "<u_vy>"
  Switch2/1 -> K2/1
  Bus Selector1/3 -> Switch2/1  "<u_vz>"
  Switch3/1 -> K1/1
  Logical Operator/1 -> Switch1/2, Switch12/2, Switch2/2, Switch3/2
  K2/1 -> Byte Pack/4
  Clock/1 -> Sum/1
  Constant/1 -> Sum/2
  Sum/1 -> Compare To Constant/1
  Compare To Constant/1 -> Logical Operator/2
  pos/1 -> Bus Selector/1
  Bus Selector/1 -> Compare To Constant1/1  "<z4>"
  u/1 -> Bus Selector1/1
  Bus Selector1/1 -> Switch12/1  "<u_vx>"
  Bus Selector1/6 -> Switch3/1  "<u_rate_yaw>"
  Bus Selector1/4 -> Byte Pack/5  "<u_rate_roll>"
  Bus Selector1/5 -> Byte Pack/6  "<u_rate_pitch>"
  Compare To Constant1/1 -> Logical Operator/1
  Byte Pack/1 -> UDP Send7/1
  Constant2/1 -> Byte Pack/1

== system e2_3_kalman_filtre_2017/send_ctrl_signal/Send Command 5 ==
  pos : Inport
  u : Inport  Port=2
  Bus Selector : BusSelector  OutputSignals=tello5_states.z5
  Bus Selector1 : BusSelector  OutputSignals=tello5.u_vx,tello5.u_vy,tello5.u_vz,tello5.u_rate_roll,tello5.u_rate_pitch,tello5.u_rate_yaw
  Byte Pack : etargetslib/Byte Pack  datatypes={'uint8','double','double','double','double','double','double'}  byteAlign=1
  Clock : Clock
  Compare To Constant : simulink/Logic and Bit Operations/Compare To Constant  relop=>=  const=0.1  OutDataTypeStr=boolean
  Compare To Constant1 : simulink/Logic and Bit Operations/Compare To Constant  relop=<  const=0  OutDataTypeStr=boolean
  Constant : Constant  Value=sim_end_time
  Constant1 : Constant  Value=0
  Constant2 : Constant  Value=TELLO5_NUM
  K : Gain  Gain=-1
  K1 : Gain
  K2 : Gain  Gain=-1
  Logical Operator : Logic  AllPortsSameDT=off  OutDataTypeStr=boolean
  Sum : Sum  Inputs=|-+
  Switch{1..3,12} (4 alike) : Switch  Criteria=u2 > Threshold  Threshold=0.001
  UDP Send7 : dspnetwork/UDP Send  remoteURL=UDP_SEND_IP  remotePort=TELLO5_SEND_PORT  localURL='0.0.0.0'  localPortSource=Automatically determine  localPort=-1  sampletime=-1  blockPlatform=[]  separateLengthPort=0
  wires:
  Constant1/1 -> Switch3/3, Switch2/3, Switch1/3, Switch12/3
  K/1 -> Byte Pack/3
  K1/1 -> Byte Pack/7
  Switch12/1 -> Byte Pack/2
  Switch1/1 -> K/1
  Bus Selector1/2 -> Switch1/1  "<u_vy>"
  Switch2/1 -> K2/1
  Bus Selector1/3 -> Switch2/1  "<u_vz>"
  Switch3/1 -> K1/1
  Logical Operator/1 -> Switch1/2, Switch12/2, Switch2/2, Switch3/2
  K2/1 -> Byte Pack/4
  Clock/1 -> Sum/1
  Constant/1 -> Sum/2
  Sum/1 -> Compare To Constant/1
  Compare To Constant/1 -> Logical Operator/2
  pos/1 -> Bus Selector/1
  Bus Selector/1 -> Compare To Constant1/1  "<z5>"
  u/1 -> Bus Selector1/1
  Bus Selector1/1 -> Switch12/1  "<u_vx>"
  Bus Selector1/6 -> Switch3/1  "<u_rate_yaw>"
  Bus Selector1/4 -> Byte Pack/5  "<u_rate_roll>"
  Bus Selector1/5 -> Byte Pack/6  "<u_rate_pitch>"
  Compare To Constant1/1 -> Logical Operator/1
  Byte Pack/1 -> UDP Send7/1
  Constant2/1 -> Byte Pack/1

== system e2_3_kalman_filtre_2017/send_ctrl_signal/Send Command 6 ==
  pos : Inport
  u : Inport  Port=2
  Bus Selector : BusSelector  OutputSignals=tello6_states.z6
  Bus Selector1 : BusSelector  OutputSignals=tello6.u_vx,tello6.u_vy,tello6.u_vz,tello6.u_rate_roll,tello6.u_rate_pitch,tello6.u_rate_yaw
  Byte Pack : etargetslib/Byte Pack  datatypes={'uint8','double','double','double','double','double','double'}  byteAlign=1
  Clock : Clock
  Compare To Constant : simulink/Logic and Bit Operations/Compare To Constant  relop=>=  const=0.1  OutDataTypeStr=boolean
  Compare To Constant1 : simulink/Logic and Bit Operations/Compare To Constant  relop=<  const=0  OutDataTypeStr=boolean
  Constant : Constant  Value=sim_end_time
  Constant1 : Constant  Value=0
  Constant2 : Constant  Value=TELLO6_NUM
  K : Gain  Gain=-1
  K1 : Gain
  K2 : Gain  Gain=-1
  Logical Operator : Logic  AllPortsSameDT=off  OutDataTypeStr=boolean
  Sum : Sum  Inputs=|-+
  Switch{1..3,12} (4 alike) : Switch  Criteria=u2 > Threshold  Threshold=0.001
  UDP Send7 : dspnetwork/UDP Send  remoteURL=UDP_SEND_IP  remotePort=TELLO6_SEND_PORT  localURL='0.0.0.0'  localPortSource=Automatically determine  localPort=-1  sampletime=-1  blockPlatform=[]  separateLengthPort=0
  wires:
  Constant1/1 -> Switch3/3, Switch2/3, Switch1/3, Switch12/3
  K/1 -> Byte Pack/3
  K1/1 -> Byte Pack/7
  Switch12/1 -> Byte Pack/2
  Switch1/1 -> K/1
  Bus Selector1/2 -> Switch1/1  "<u_vy>"
  Switch2/1 -> K2/1
  Bus Selector1/3 -> Switch2/1  "<u_vz>"
  Switch3/1 -> K1/1
  Logical Operator/1 -> Switch1/2, Switch12/2, Switch2/2, Switch3/2
  K2/1 -> Byte Pack/4
  Clock/1 -> Sum/1
  Constant/1 -> Sum/2
  Sum/1 -> Compare To Constant/1
  Compare To Constant/1 -> Logical Operator/2
  pos/1 -> Bus Selector/1
  Bus Selector/1 -> Compare To Constant1/1  "<z6>"
  u/1 -> Bus Selector1/1
  Bus Selector1/1 -> Switch12/1  "<u_vx>"
  Bus Selector1/6 -> Switch3/1  "<u_rate_yaw>"
  Bus Selector1/4 -> Byte Pack/5  "<u_rate_roll>"
  Bus Selector1/5 -> Byte Pack/6  "<u_rate_pitch>"
  Compare To Constant1/1 -> Logical Operator/1
  Byte Pack/1 -> UDP Send7/1
  Constant2/1 -> Byte Pack/1

== system e2_3_kalman_filtre_2017/send_ctrl_signal/Send Command 7 ==
  pos : Inport
  u : Inport  Port=2
  Bus Selector : BusSelector  OutputSignals=tello7_states.z7
  Bus Selector1 : BusSelector  OutputSignals=tello7.u_vx,tello7.u_vy,tello7.u_vz,tello7.u_rate_roll,tello7.u_rate_pitch,tello7.u_rate_yaw
  Byte Pack : etargetslib/Byte Pack  datatypes={'uint8','double','double','double','double','double','double'}  byteAlign=1
  Clock : Clock
  Compare To Constant : simulink/Logic and Bit Operations/Compare To Constant  relop=>=  const=0.1  OutDataTypeStr=boolean
  Compare To Constant1 : simulink/Logic and Bit Operations/Compare To Constant  relop=<  const=0  OutDataTypeStr=boolean
  Constant : Constant  Value=sim_end_time
  Constant1 : Constant  Value=0
  Constant2 : Constant  Value=TELLO7_NUM
  K : Gain  Gain=-1
  K1 : Gain
  K2 : Gain  Gain=-1
  Logical Operator : Logic  AllPortsSameDT=off  OutDataTypeStr=boolean
  Sum : Sum  Inputs=|-+
  Switch{1..3,12} (4 alike) : Switch  Criteria=u2 > Threshold  Threshold=0.001
  UDP Send7 : dspnetwork/UDP Send  remoteURL=UDP_SEND_IP  remotePort=TELLO7_SEND_PORT  localURL='0.0.0.0'  localPortSource=Automatically determine  localPort=-1  sampletime=-1  blockPlatform=[]  separateLengthPort=0
  wires:
  Constant1/1 -> Switch3/3, Switch2/3, Switch1/3, Switch12/3
  K/1 -> Byte Pack/3
  K1/1 -> Byte Pack/7
  Switch12/1 -> Byte Pack/2
  Switch1/1 -> K/1
  Bus Selector1/2 -> Switch1/1  "<u_vy>"
  Switch2/1 -> K2/1
  Bus Selector1/3 -> Switch2/1  "<u_vz>"
  Switch3/1 -> K1/1
  Logical Operator/1 -> Switch1/2, Switch12/2, Switch2/2, Switch3/2
  K2/1 -> Byte Pack/4
  Clock/1 -> Sum/1
  Constant/1 -> Sum/2
  Sum/1 -> Compare To Constant/1
  Compare To Constant/1 -> Logical Operator/2
  pos/1 -> Bus Selector/1
  Bus Selector/1 -> Compare To Constant1/1  "<z7>"
  u/1 -> Bus Selector1/1
  Bus Selector1/1 -> Switch12/1  "<u_vx>"
  Bus Selector1/6 -> Switch3/1  "<u_rate_yaw>"
  Bus Selector1/4 -> Byte Pack/5  "<u_rate_roll>"
  Bus Selector1/5 -> Byte Pack/6  "<u_rate_pitch>"
  Compare To Constant1/1 -> Logical Operator/1
  Byte Pack/1 -> UDP Send7/1
  Constant2/1 -> Byte Pack/1

== system e2_3_kalman_filtre_2017/send_ctrl_signal/Send Command 8 ==
  pos : Inport
  u : Inport  Port=2
  Bus Selector : BusSelector  OutputSignals=tello8_states.z8
  Bus Selector1 : BusSelector  OutputSignals=tello8.u_vx,tello8.u_vy,tello8.u_vz,tello8.u_rate_roll,tello8.u_rate_pitch,tello8.u_rate_yaw
  Byte Pack : etargetslib/Byte Pack  datatypes={'uint8','double','double','double','double','double','double'}  byteAlign=1
  Clock : Clock
  Compare To Constant : simulink/Logic and Bit Operations/Compare To Constant  relop=>=  const=0.1  OutDataTypeStr=boolean
  Compare To Constant1 : simulink/Logic and Bit Operations/Compare To Constant  relop=<  const=0  OutDataTypeStr=boolean
  Constant : Constant  Value=sim_end_time
  Constant1 : Constant  Value=0
  Constant2 : Constant  Value=TELLO8_NUM
  K : Gain  Gain=-1
  K1 : Gain
  K2 : Gain  Gain=-1
  Logical Operator : Logic  AllPortsSameDT=off  OutDataTypeStr=boolean
  Sum : Sum  Inputs=|-+
  Switch{1..3,12} (4 alike) : Switch  Criteria=u2 > Threshold  Threshold=0.001
  UDP Send7 : dspnetwork/UDP Send  remoteURL=UDP_SEND_IP  remotePort=TELLO8_SEND_PORT  localURL='0.0.0.0'  localPortSource=Automatically determine  localPort=-1  sampletime=-1  blockPlatform=[]  separateLengthPort=0
  wires:
  Constant1/1 -> Switch3/3, Switch2/3, Switch1/3, Switch12/3
  K/1 -> Byte Pack/3
  K1/1 -> Byte Pack/7
  Switch12/1 -> Byte Pack/2
  Switch1/1 -> K/1
  Bus Selector1/2 -> Switch1/1  "<u_vy>"
  Switch2/1 -> K2/1
  Bus Selector1/3 -> Switch2/1  "<u_vz>"
  Switch3/1 -> K1/1
  Logical Operator/1 -> Switch1/2, Switch12/2, Switch2/2, Switch3/2
  K2/1 -> Byte Pack/4
  Clock/1 -> Sum/1
  Constant/1 -> Sum/2
  Sum/1 -> Compare To Constant/1
  Compare To Constant/1 -> Logical Operator/2
  pos/1 -> Bus Selector/1
  Bus Selector/1 -> Compare To Constant1/1  "<z8>"
  u/1 -> Bus Selector1/1
  Bus Selector1/1 -> Switch12/1  "<u_vx>"
  Bus Selector1/6 -> Switch3/1  "<u_rate_yaw>"
  Bus Selector1/4 -> Byte Pack/5  "<u_rate_roll>"
  Bus Selector1/5 -> Byte Pack/6  "<u_rate_pitch>"
  Compare To Constant1/1 -> Logical Operator/1
  Byte Pack/1 -> UDP Send7/1
  Constant2/1 -> Byte Pack/1

== system e2_3_kalman_filtre_2017/CMD/CMD1/Signal Builder ==
  Demux : Demux  Tag=STV Demux  Outputs=1
  FromWs : FromWorkspace  Tag=STV FromWs  VariableName=tuvar  SampleTime=0
  Signal 2 : Outport  Tag=STV Outport
  wires:
  FromWs/1 -> Demux/1
  Demux/1 -> Signal 2/1

== system e2_3_kalman_filtre_2017/CMD/CMD1/command function ==
  note: command function
  time : Inport
  Constant : Constant  Value=fcnNumber
  Data Type Conversion : DataTypeConversion  OutDataTypeStr=double
  Index Vector : MultiPortSwitch  Inputs=4
  Saturation : Saturate  UpperLimit=inf  LowerLimit=0
  Sine Wave : Sin  TimeSource=Use external signal  Amplitude=fcnCmdMag  Frequency=fcnSinFreq  SampleTime=0
  Subtract2 : Sum  Inputs=-+
  chirp function : Subsystem
  step function : Subsystem
  step+chirp function : Subsystem
  time_start : Constant  Value=PARAM_time_start
  time_switch : Subsystem
  fcnCmd : Outport
  wires:
  step+chirp function/1(Cmd Out) -> Index Vector/5
  Saturation/1 -> step+chirp function/1(time), chirp function/1(time), Data Type Conversion/1, step function/1(time)
  time_start/1 -> Subtract2/1
  Subtract2/1 -> Saturation/1
  chirp function/1(chirp out) -> Index Vector/4
  Sine Wave/1 -> Index Vector/3
  Constant/1 -> Index Vector/1
  time/1 -> Subtract2/2, time_switch/2(time)
  step function/1(stepOut) -> Index Vector/2
  Data Type Conversion/1 -> Sine Wave/1
  Index Vector/1 -> time_switch/1(input)
  time_switch/1(Output) -> fcnCmd/1

== system e2_3_kalman_filtre_2017/CMD/CMD2/Subsystem ==
  clock : Inport
  Constant1 : Constant  Value=k
  Constant10 : Constant  Value=tb4
  Constant2 : Constant  Value=sim_end_time
  Constant3 : Constant  Value=bb
  Constant4 : Constant  Value=w1
  Constant5 : Constant  Value=a
  Constant6 : Constant  Value=w2
  Constant7 : Constant  Value=b
  Constant8 : Constant  Value=tb2
  Constant9 : Constant  Value=tb3
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  "x " : Outport
  y : Outport  Port=2
  z : Outport  Port=3
  wires:
  MATLAB Function/1(x2_) -> "x "/1
  MATLAB Function/2(y2_) -> y/1
  MATLAB Function/3(z2_) -> z/1
  clock/1 -> MATLAB Function/1(timestamp)
  Constant2/1 -> MATLAB Function/2(sim_end_time)
  Constant5/1 -> MATLAB Function/3(a)
  Constant7/1 -> MATLAB Function/4(b)
  Constant1/1 -> MATLAB Function/5(k)
  Constant3/1 -> MATLAB Function/6(bb)
  Constant4/1 -> MATLAB Function/7(w1)
  Constant6/1 -> MATLAB Function/8(w2)
  Constant8/1 -> MATLAB Function/9(tb2)
  Constant9/1 -> MATLAB Function/10(tb3)
  Constant10/1 -> MATLAB Function/11(tb4)

== system e2_3_kalman_filtre_2017/CMD/CMD3/Subsystem1 ==
  clock : Inport
  Constant1 : Constant  Value=k
  Constant10 : Constant  Value=tb4
  Constant2 : Constant  Value=sim_end_time
  Constant3 : Constant  Value=bb
  Constant4 : Constant  Value=w1
  Constant5 : Constant  Value=a
  Constant6 : Constant  Value=w2
  Constant7 : Constant  Value=b
  Constant8 : Constant  Value=tb2
  Constant9 : Constant  Value=tb3
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  "x " : Outport
  y : Outport  Port=2
  z : Outport  Port=3
  wires:
  Constant10/1 -> MATLAB Function/11(tb4)
  Constant9/1 -> MATLAB Function/10(tb3)
  Constant8/1 -> MATLAB Function/9(tb2)
  Constant6/1 -> MATLAB Function/8(w2)
  Constant4/1 -> MATLAB Function/7(w1)
  Constant3/1 -> MATLAB Function/6(bb)
  Constant1/1 -> MATLAB Function/5(k)
  Constant7/1 -> MATLAB Function/4(b)
  Constant5/1 -> MATLAB Function/3(a)
  Constant2/1 -> MATLAB Function/2(sim_end_time)
  clock/1 -> MATLAB Function/1(timestamp)
  MATLAB Function/3(z3_) -> z/1
  MATLAB Function/2(y3_) -> y/1
  MATLAB Function/1(x3_) -> "x "/1

== system e2_3_kalman_filtre_2017/CMD/CMD4/Subsystem ==
  clock : Inport
  Constant1 : Constant  Value=k
  Constant10 : Constant  Value=tb4
  Constant2 : Constant  Value=sim_end_time
  Constant3 : Constant  Value=bb
  Constant4 : Constant  Value=w1
  Constant5 : Constant  Value=a
  Constant6 : Constant  Value=w2
  Constant7 : Constant  Value=b
  Constant8 : Constant  Value=tb2
  Constant9 : Constant  Value=tb3
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  "x " : Outport
  y : Outport  Port=2
  z : Outport  Port=3
  wires:
  MATLAB Function/1(x4_) -> "x "/1
  MATLAB Function/2(y4_) -> y/1
  MATLAB Function/3(z4_) -> z/1
  clock/1 -> MATLAB Function/1(timestamp)
  Constant2/1 -> MATLAB Function/2(sim_end_time)
  Constant5/1 -> MATLAB Function/3(a)
  Constant7/1 -> MATLAB Function/4(b)
  Constant1/1 -> MATLAB Function/5(k)
  Constant3/1 -> MATLAB Function/6(bb)
  Constant4/1 -> MATLAB Function/7(w1)
  Constant6/1 -> MATLAB Function/8(w2)
  Constant8/1 -> MATLAB Function/9(tb2)
  Constant9/1 -> MATLAB Function/10(tb3)
  Constant10/1 -> MATLAB Function/11(tb4)

== system e2_3_kalman_filtre_2017/CMD/CMD5/Subsystem ==
  clock : Inport
  Constant1 : Constant  Value=k
  Constant10 : Constant  Value=tb4
  Constant11 : Constant  Value=tb8
  Constant12 : Constant  Value=tb6
  Constant13 : Constant  Value=tb7
  Constant14 : Constant  Value=tb5
  Constant2 : Constant  Value=sim_end_time
  Constant3 : Constant  Value=bb
  Constant4 : Constant  Value=w1
  Constant5 : Constant  Value=a
  Constant6 : Constant  Value=w2
  Constant7 : Constant  Value=b
  Constant8 : Constant  Value=tb2
  Constant9 : Constant  Value=tb3
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  "x " : Outport
  y : Outport  Port=2
  z : Outport  Port=3
  wires:
  MATLAB Function/1(x5_) -> "x "/1
  MATLAB Function/2(y5_) -> y/1
  MATLAB Function/3(z5_) -> z/1
  clock/1 -> MATLAB Function/1(timestamp)
  Constant2/1 -> MATLAB Function/2(sim_end_time)
  Constant5/1 -> MATLAB Function/3(a)
  Constant7/1 -> MATLAB Function/4(b)
  Constant1/1 -> MATLAB Function/5(k)
  Constant3/1 -> MATLAB Function/6(bb)
  Constant4/1 -> MATLAB Function/7(w1)
  Constant6/1 -> MATLAB Function/8(w2)
  Constant8/1 -> MATLAB Function/9(tb2)
  Constant9/1 -> MATLAB Function/10(tb3)
  Constant10/1 -> MATLAB Function/11(tb4)
  Constant11/1 -> MATLAB Function/15(tb8)
  Constant13/1 -> MATLAB Function/14(tb7)
  Constant12/1 -> MATLAB Function/13(tb6)
  Constant14/1 -> MATLAB Function/12(tb5)

== system e2_3_kalman_filtre_2017/CMD/CMD6/Subsystem ==
  clock : Inport
  Constant1 : Constant  Value=k
  Constant10 : Constant  Value=tb4
  Constant11 : Constant  Value=tb8
  Constant12 : Constant  Value=tb6
  Constant13 : Constant  Value=tb7
  Constant14 : Constant  Value=tb5
  Constant2 : Constant  Value=sim_end_time
  Constant3 : Constant  Value=bb
  Constant4 : Constant  Value=w1
  Constant5 : Constant  Value=a
  Constant6 : Constant  Value=w2
  Constant7 : Constant  Value=b
  Constant8 : Constant  Value=tb2
  Constant9 : Constant  Value=tb3
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  "x " : Outport
  y : Outport  Port=2
  z : Outport  Port=3
  wires:
  MATLAB Function/1(x6_) -> "x "/1
  MATLAB Function/2(y6_) -> y/1
  MATLAB Function/3(z6_) -> z/1
  clock/1 -> MATLAB Function/1(timestamp)
  Constant2/1 -> MATLAB Function/2(sim_end_time)
  Constant5/1 -> MATLAB Function/3(a)
  Constant7/1 -> MATLAB Function/4(b)
  Constant1/1 -> MATLAB Function/5(k)
  Constant3/1 -> MATLAB Function/6(bb)
  Constant4/1 -> MATLAB Function/7(w1)
  Constant6/1 -> MATLAB Function/8(w2)
  Constant8/1 -> MATLAB Function/9(tb2)
  Constant9/1 -> MATLAB Function/10(tb3)
  Constant10/1 -> MATLAB Function/11(tb4)
  Constant11/1 -> MATLAB Function/15(tb8)
  Constant13/1 -> MATLAB Function/14(tb7)
  Constant12/1 -> MATLAB Function/13(tb6)
  Constant14/1 -> MATLAB Function/12(tb5)

== system e2_3_kalman_filtre_2017/CMD/CMD7/Subsystem ==
  clock : Inport
  Constant1 : Constant  Value=k
  Constant10 : Constant  Value=tb4
  Constant11 : Constant  Value=tb8
  Constant12 : Constant  Value=tb6
  Constant13 : Constant  Value=tb7
  Constant14 : Constant  Value=tb5
  Constant2 : Constant  Value=sim_end_time
  Constant3 : Constant  Value=bb
  Constant4 : Constant  Value=w1
  Constant5 : Constant  Value=a
  Constant6 : Constant  Value=w2
  Constant7 : Constant  Value=b
  Constant8 : Constant  Value=tb2
  Constant9 : Constant  Value=tb3
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  "x " : Outport
  y : Outport  Port=2
  z : Outport  Port=3
  wires:
  MATLAB Function/1(x7_) -> "x "/1
  MATLAB Function/2(y7_) -> y/1
  MATLAB Function/3(z7_) -> z/1
  clock/1 -> MATLAB Function/1(timestamp)
  Constant2/1 -> MATLAB Function/2(sim_end_time)
  Constant5/1 -> MATLAB Function/3(a)
  Constant7/1 -> MATLAB Function/4(b)
  Constant1/1 -> MATLAB Function/5(k)
  Constant3/1 -> MATLAB Function/6(bb)
  Constant4/1 -> MATLAB Function/7(w1)
  Constant6/1 -> MATLAB Function/8(w2)
  Constant8/1 -> MATLAB Function/9(tb2)
  Constant9/1 -> MATLAB Function/10(tb3)
  Constant10/1 -> MATLAB Function/11(tb4)
  Constant11/1 -> MATLAB Function/15(tb8)
  Constant13/1 -> MATLAB Function/14(tb7)
  Constant12/1 -> MATLAB Function/13(tb6)
  Constant14/1 -> MATLAB Function/12(tb5)

== system e2_3_kalman_filtre_2017/CMD/CMD8/Subsystem ==
  clock : Inport
  Constant1 : Constant  Value=k
  Constant10 : Constant  Value=tb4
  Constant11 : Constant  Value=tb8
  Constant12 : Constant  Value=tb6
  Constant13 : Constant  Value=tb7
  Constant14 : Constant  Value=tb5
  Constant2 : Constant  Value=sim_end_time
  Constant3 : Constant  Value=bb
  Constant4 : Constant  Value=w1
  Constant5 : Constant  Value=a
  Constant6 : Constant  Value=w2
  Constant7 : Constant  Value=b
  Constant8 : Constant  Value=tb2
  Constant9 : Constant  Value=tb3
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  "x " : Outport
  y : Outport  Port=2
  z : Outport  Port=3
  wires:
  MATLAB Function/1(x8_) -> "x "/1
  MATLAB Function/2(y8_) -> y/1
  MATLAB Function/3(z8_) -> z/1
  clock/1 -> MATLAB Function/1(timestamp)
  Constant2/1 -> MATLAB Function/2(sim_end_time)
  Constant5/1 -> MATLAB Function/3(a)
  Constant7/1 -> MATLAB Function/4(b)
  Constant1/1 -> MATLAB Function/5(k)
  Constant3/1 -> MATLAB Function/6(bb)
  Constant4/1 -> MATLAB Function/7(w1)
  Constant6/1 -> MATLAB Function/8(w2)
  Constant8/1 -> MATLAB Function/9(tb2)
  Constant9/1 -> MATLAB Function/10(tb3)
  Constant10/1 -> MATLAB Function/11(tb4)
  Constant11/1 -> MATLAB Function/15(tb8)
  Constant13/1 -> MATLAB Function/14(tb7)
  Constant12/1 -> MATLAB Function/13(tb6)
  Constant14/1 -> MATLAB Function/12(tb5)

== system e2_3_kalman_filtre_2017/control system/Baseline Controller Basic/Controller X ==
  X_e (m) : Inport
  X_d (m) : Inport  Port=2
  V_x_e : Inport  Port=3
  Kd : Gain  Gain=0.2
  Kp : Gain  Gain=0.9
  Sum2 : Sum  Inputs=|+-
  Sum3 : Sum  Inputs=|-+
  U_x : Outport
  wires:
  Kp/1 -> Sum2/1
  V_x_e/1 -> Kd/1
  X_e (m)/1 -> Sum3/1
  Kd/1 -> Sum2/2
  Sum3/1 -> Kp/1
  Sum2/1 -> U_x/1
  X_d (m)/1 -> Sum3/2

== system e2_3_kalman_filtre_2017/control system/Baseline Controller Basic/Controller Y ==
  Y_e (m) : Inport
  Y_d (m) : Inport  Port=2
  V_y_e : Inport  Port=3
  Kd1 : Gain  Gain=0.2
  Kp2 : Gain  Gain=0.9
  Sum5 : Sum  Inputs=|+-
  Sum6 : Sum  Inputs=|-+
  uy : Outport
  wires:
  Y_d (m)/1 -> Sum6/2
  V_y_e/1 -> Kd1/1
  Kp2/1 -> Sum5/1
  Sum5/1 -> uy/1
  Sum6/1 -> Kp2/1
  Kd1/1 -> Sum5/2
  Y_e (m)/1 -> Sum6/1

== system e2_3_kalman_filtre_2017/control system/Baseline Controller Basic/Decoupling ==
  note: car coordination
  Ux : Inport
  yaw_e : Inport  Port=2
  Uy : Inport  Port=3
  Constant : Constant  Value=omega*R*2
  "Coordinate trnasformation from inertial frame to body frame " : MATLAB Function  TreatAsAtomicUnit=on
  Demux : Demux  Outputs=2
  Gain1 : Gain  Gain=-1
  MATLAB Function : MATLAB Function  TreatAsAtomicUnit=on
  Mux : Mux  Inputs=2
  D_Ux : Outport
  D_Uy : Outport  Port=2
  wires:
  MATLAB Function/1(y) -> Demux/1
  Gain1/1 -> "Coordinate trnasformation from inertial frame to body frame "/2(psi)
  yaw_e/1 -> Gain1/1
  Demux/1 -> D_Ux/1
  Mux/1 -> "Coordinate trnasformation from inertial frame to body frame "/1(Vec_i)
  "Coordinate trnasformation from inertial frame to body frame "/1(Vec_xy) -> MATLAB Function/1(u)
  Demux/2 -> D_Uy/1
  Constant/1 -> MATLAB Function/2(a)
  Uy/1 -> Mux/2
  Ux/1 -> Mux/1

== system e2_3_kalman_filtre_2017/control system/Baseline Controller Basic/Heading controller ==
  yaw_e (rad) : Inport
  yaw_d. (rad) : Inport  Port=2
  Sum1 : Sum  Inputs=|-+
  Sum2 : Sum  Inputs=|++
  proportional control gain - yaw : Gain  Gain=0.8
  yaw_rate_d. (rad/s) : Outport
  wires:
  Sum1/1 -> proportional control gain - yaw/1
  yaw_e (rad)/1 -> Sum1/1
  yaw_d. (rad)/1 -> Sum1/2
  proportional control gain - yaw/1 -> Sum2/1
  Sum2/1 -> yaw_rate_d. (rad/s)/1

== system e2_3_kalman_filtre_2017/control system/Baseline Controller Basic/Height controller  ==
  Z_d. (m) : Inport
  Z_e (m) : Inport  Port=2
  V_z : Inport  Port=3
  Kd : Gain  Gain=0.2
  Kp : Gain  Gain=1.2
  Sum2 : Sum  Inputs=|+-
  Sum3 : Sum  Inputs=|-+
  Z_velocity_d (m/s) : Outport
  wires:
  Z_e (m)/1 -> Sum3/1
  Z_d. (m)/1 -> Sum3/2
  Sum3/1 -> Kp/1
  Kp/1 -> Sum2/1
  Sum2/1 -> Z_velocity_d (m/s)/1
  V_z/1 -> Kd/1
  Kd/1 -> Sum2/2

== system e2_3_kalman_filtre_2017/control system/Baseline Controller2/Heading controller ==
  yaw_e (rad) : Inport
  yaw_d. (rad) : Inport  Port=2
  Integrator Limited : Integrator  Commented=on  LimitOutput=on  UpperSaturationLimit=0.3  LowerSaturationLimit=-0.3
  Ki : Gain  Commented=on  Gain=0.01
  Sum1 : Sum  Inputs=|-+
  Sum2 : Sum  Inputs=|++
  proportional control gain - yaw : Gain  Gain=1.0
  yaw_rate_d. (rad/s) : Outport
  wires:
  Sum2/1 -> yaw_rate_d. (rad/s)/1
  Ki/1 -> Integrator Limited/1
  Integrator Limited/1 -> Sum2/2
  proportional control gain - yaw/1 -> Sum2/1
  yaw_d. (rad)/1 -> Sum1/2
  yaw_e (rad)/1 -> Sum1/1
  Sum1/1 -> proportional control gain - yaw/1, Ki/1

== system e2_3_kalman_filtre_2017/control system/Baseline Controller2/Height controller  ==
  Z_d. (m) : Inport
  Z_e (m) : Inport  Port=2
  V_z : Inport  Port=3
  Integrator Limited : Integrator  LimitOutput=on  UpperSaturationLimit=0.5  LowerSaturationLimit=-0.5
  Kd : Gain  Gain=0.01
  Kp : Gain  Gain=1.0
  Kp1 : Gain  Gain=0.01
  Sum1 : Sum  Inputs=|-+
  Sum2 : Sum  Inputs=+++
  Sum3 : Sum  Inputs=|-+
  Transfer Fcn1 : TransferFcn  Denominator=[1/(2*pi*10) 1]
  Z_velocity_d (m/s) : Outport
  wires:
  Z_d. (m)/1 -> Sum3/2
  Transfer Fcn1/1 -> Sum1/1
  Integrator Limited/1 -> Sum2/1
  Kp1/1 -> Integrator Limited/1
  Kd/1 -> Sum2/3
  Kp/1 -> Sum2/2
  Sum2/1 -> Z_velocity_d (m/s)/1
  Sum1/1 -> Kd/1
  V_z/1 -> Transfer Fcn1/1
  Z_e (m)/1 -> Sum3/1
  Sum3/1 -> Kp/1, Kp1/1
