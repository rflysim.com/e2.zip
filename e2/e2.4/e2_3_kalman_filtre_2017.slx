simulink model "e2_3_kalman_filtre_2017"  (R2018b)
settings: Solver=FixedStepAuto  StartTime=0.0  StopTime=30  FixedStep=fixed_step_size  RelTol=1e-3
StopFcn:
  | if AUTOLAND
  | %1_2
  | land1 = rospublisher('/tello1/land','std_msgs/Empty');
  | msg=rosmessage(land1);
  | send(land1,msg);
  | land2 = rospublisher('/tello2/land','std_msgs/Empty');
  | msg=rosmessage(land2);
  | send(land2,msg);
  | %3_4
  | land3 = rospublisher('/tello3/land','std_msgs/Empty');
  | msg=rosmessage(land3);
  | send(land3,msg);
  | land4 = rospublisher('/tello4/land','std_msgs/Empty');
  | msg=rosmessage(land4);
  | send(land4,msg);
  | %5_6
  | land5 = rospublisher('/tello5/land','std_msgs/Empty');
  | msg=rosmessage(land5);
  | send(land5,msg);
  | land6= rospublisher('/tello6/land','std_msgs/Empty');
  | msg=rosmessage(land6);
  | send(land6,msg);
  | %7_8
  | land7 = rospublisher('/tello7/land','std_msgs/Empty');
  | msg=rosmessage(land7);
  | send(land7,msg);
  | land8 = rospublisher('/tello8/land','std_msgs/Empty');
  | msg=rosmessage(land8);
  | send(land8,msg);
  | end
  | 
  | generate_cifer_datapack
  | 
  | if TELLO_PLOT
  | tello8_plot
  | end
values from neighbouring files (symbols this model uses):
  a = XMAX    (= 0.8)    [start_tello.m]
  b = YMAX    (= 1.2)    [start_tello.m]
  battery_threshold = 15    [start_tello.m]
  bb = (ZMIN*YMAX - ZMAX*YMIN)/(YMAX - YMIN)    (= -1.05)    [start_tello.m]
  fcnCmdMag = 1    [start.m]
  fcnNumber = 4    [start.m]
  fcnSinFreq = 50.0    (= 50)    [start.m]
  high_time = 5    [start.m]
  k = (ZMAX - ZMIN)/(YMAX - YMIN)    (= 0.458333333333)    [start_tello.m]
  omega = 1.0    (= 1)    [start.m]    (also in start_tello.m = 0.3)
  PARAM_C1 = 4.0    (= 4)    [start.m]
  PARAM_C2 = 0.0187    [start.m]
  PARAM_isNoiseOn = false    [start.m]
  PARAM_T_rec = ceil(5*2*pi/PARAM_w_min)    [start.m]
  PARAM_time_end = PARAM_time_start + 20    (= 23)    [start.m]
  PARAM_time_start = 3    [start.m]
  PARAM_w_max = 12    [start.m]
  PARAM_w_min = 0.5    [start.m]
  R = 1.0    (= 1)    [start.m]    (also in start_tello.m)
  sim_end_time = 15*act_end + 4    (= 475.238898038)    [start_tello.m]
  step_period = zero1_time+high_time+zero2_time+low_time    (= 18)    [start.m]
  tb2 = tb    (= 2.7)    [start_tello.m]
  tb3 = tb*2    (= 5.4)    [start_tello.m]
  tb4 = tb*3    (= 8.1)    [start_tello.m]
  tb5 = tb*4    (= 10.8)    [start_tello.m]
  tb6 = tb*5    (= 13.5)    [start_tello.m]
  tb7 = tb*6    (= 16.2)    [start_tello.m]
  tb8 = tb*7    (= 18.9)    [start_tello.m]
  TELLO1_NUM = uint8(1)    [start_tello.m]
  TELLO2_NUM = uint8(2)    [start_tello.m]
  TELLO3_NUM = uint8(3)    [start_tello.m]
  TELLO4_NUM = uint8(4)    [start_tello.m]
  TELLO5_NUM = uint8(5)    [start_tello.m]
  TELLO6_NUM = uint8(6)    [start_tello.m]
  TELLO7_NUM = uint8(7)    [start_tello.m]
  TELLO8_NUM = uint8(8)    [start_tello.m]
  UAV_NUM = 0    [start_tello.m]
  w1 = 0.4    [start_tello.m]
  w2 = 0.2    [start_tello.m]
  z_d_for_land = -0.2    [start_tello.m]
  zero1_time = 3    [start.m]
  zero2_time = 5    [start.m]
  zero3_time = 5    [start.m]
undefined symbols (not defined in the file or in its folder): DiscIntNeverNeededParam, sigbuilder_block
libraries: simulink x45, etargetslib x24, dspnetwork x24, sharedtransform x8, aerolibanimutils x1
(part 4 of 4)

== system e2_3_kalman_filtre_2017/CMD/CMD1/command function/step+chirp function/step function1/Subsystem1 ==
  time : Inport
  0cmd : Inport  Port=2
  1cmd : Inport  Port=3
  Divide : Product  Inputs=*/
  Switch : Switch  Threshold=1
  threshold : Constant  Value=zero1_time+high_time
  timeOut : Outport
  Out : Outport  Port=2
  wires:
  0cmd/1 -> Switch/3
  time/1 -> timeOut/1, Divide/1
  1cmd/1 -> Switch/1
  Switch/1 -> Out/1
  Divide/1 -> Switch/2
  threshold/1 -> Divide/2

== system e2_3_kalman_filtre_2017/CMD/CMD1/command function/step+chirp function/step function1/Subsystem2 ==
  time : Inport
  0cmd : Inport  Port=2
  1cmd : Inport  Port=3
  Divide : Product  Inputs=*/
  Switch : Switch  Threshold=1
  threshold : Constant  Value=zero1_time+high_time+zero2_time
  timeOut : Outport
  Out : Outport  Port=2
  wires:
  threshold/1 -> Divide/2
  Divide/1 -> Switch/2
  Switch/1 -> Out/1
  1cmd/1 -> Switch/1
  time/1 -> Divide/1, timeOut/1
  0cmd/1 -> Switch/3

== system e2_3_kalman_filtre_2017/CMD/CMD1/command function/step+chirp function/step function1/Subsystem3 ==
  time : Inport
  0cmd : Inport  Port=2
  1cmd : Inport  Port=3
  Divide : Product  Inputs=*/
  Switch : Switch  Threshold=1
  threshold : Constant  Value=step_period
  timeOut : Outport
  Out : Outport  Port=2
  wires:
  0cmd/1 -> Switch/3
  time/1 -> timeOut/1, Divide/1
  1cmd/1 -> Switch/1
  Switch/1 -> Out/1
  Divide/1 -> Switch/2
  threshold/1 -> Divide/2

== matlab function e2_3_kalman_filtre_2017/control system/Baseline Controller2/MATLAB Function ==
function y = fcn(u,a)
y = satgd(u,a);

== matlab function e2_3_kalman_filtre_2017/control system/Baseline Controller2/Position controller/Coordinate trnasformation 
from inertial frame to body frame  ==
function Vec_xy  = fcn(Vec_i , psi)
%#codegen
T = [cos(psi) sin(psi) ; -sin(psi) cos(psi)] ; 
Vec_xy = T*Vec_i(1:2,1);

== matlab function e2_3_kalman_filtre_2017/CMD/CMD2/Subsystem/MATLAB Function ==
function [x2_, y2_, z2_] = fcn(timestamp, sim_end_time, a, b, k, bb, w1, w2,tb2, tb3, tb4)
persistent time_start;
if isempty(time_start)
     time_start = timestamp;
end

if (timestamp - time_start) < 2
    t = 0;
elseif (sim_end_time - timestamp) >=2
    t = timestamp - 2;
else
    t = sim_end_time - 4;
end
    x2_ = a*sin(w1*(t - tb2));
    y2_ = b*cos(w2*(t - tb2));
    z2_ = k*y2_+bb;

== matlab function e2_3_kalman_filtre_2017/control system/Kalman_Filtre/Kalman Filtre H/Kalman Filtre H/Kalman Filtre for getting the velocity H ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity)

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
    P0_static=[0.1,0 0;0,0.1,0;0 0 0.1]; % the initilized matrice of estimated error
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.01;

% Process Noise
p_var =0.05; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise

% Mesurement Noise
m_var = 0.01; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise

% Observation matrice
H=[1 0 0];

% The indentity matrice
I=eye(3); 

% State Transition Martrix
A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];

% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% Mesurement_Velocity=H*(X_real)+V;
% X_real_static=X_real;    

%   Kalman Update process
    X_pre=A*Xkf_static; % State estimation
    P_pre=A*P0_static*A'+Q; % Covariance matrice estimation

    Kg=P_pre*H'*inv(H*P_pre*H'+R); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H*X_pre); % State estimation update
    Covariance_matrice=(I-Kg*H)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;

== matlab function e2_3_kalman_filtre_2017/CMD/CMD4/MATLAB Function ==
function [x_d_, y_d_, z_d_] = fcn(x_d, y_d, z_d, timestamp, x,y,z,battery_status, sim_time_end,battery_threshold, z_d_for_land, UAV_NUM)
persistent s_x s_y s_z ready_land
if isempty(s_x)
    s_x = x;
end
if isempty(s_y)
    s_y = y;
end
if isempty(s_z)
    s_z = z;
end
if isempty(ready_land)
    ready_land = false;
end
    
battery_low = false;
for i = 1:UAV_NUM
    if battery_status(i) < battery_threshold
        battery_low = true;
        break;
    end
end
if sim_time_end - timestamp < 1
    tello_stop = true;
else
    tello_stop = false;
end
if battery_low || tello_stop
    if ~ready_land
        s_x = x;
        s_y = y;
        ready_land = true;
    end
    z_d_ = z_d_for_land;
    x_d_ = s_x;
    y_d_ = s_y;
else
   ready_land = false;
   s_x = x;
   s_y = y;
   x_d_ = x_d;
   y_d_ = y_d;
   z_d_ = z_d;
end

== matlab function e2_3_kalman_filtre_2017/CMD/CMD4/Subsystem/MATLAB Function ==
function [x4_, y4_, z4_] = fcn(timestamp, sim_end_time, a, b, k, bb, w1, w2,tb2, tb3, tb4)
persistent time_start;
if isempty(time_start)
     time_start = timestamp;
end

if (timestamp - time_start) < 2
    t = 0;
elseif (sim_end_time - timestamp) >=2
    t = timestamp - 2;
else
    t = sim_end_time - 4;
end
    x4_ = a*sin(w1*(t - tb4));
    y4_ = b*cos(w2*(t - tb4));
    z4_ = k*y4_+bb;

== matlab function e2_3_kalman_filtre_2017/control system/Kalman_Filtre/Kalman Filtre H/Kalman Filtre for getting the velocity H ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity) % Mesurement_State

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
    P0_static=[[0.1,0 0;0,0.1,0;0 0 0.1] zeros(3) zeros(3) ;zeros(3) [0.1,0 0;0,0.1,0;0 0 0.1] zeros(3);zeros(3) zeros(3) [0.1,0 0;0,0.1,0;0 0 0.1]]; % the initilized matrice of estimated error
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0;0;0;0;0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.025;

% Process Noise
p_var =3; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise
Q_delay=[Q zeros(3) zeros(3);zeros(3) Q zeros(3);zeros(3) zeros(3) Q];
% Mesurement Noise
m_var = 0.05; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise
R_delay=R;
V_delay=R_delay*randn;
% Observation matrice
H=[1 0 0];
H_delay=[0 0 0 0 0 0 H];
% The indentity matrice
I=eye(3); 
I_delay=eye(9);

A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];
A_delay=[A zeros(3) zeros(3);zeros(3) A zeros(3); zeros(3) zeros(3) A];
% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% X_real_static=X_real;    
% Mesurement_Velocity=H_delay*(Mesurement_State)+V_delay;

%   Kalman Update process
    X_pre=A_delay*Xkf_static; % State estimation
    P_pre=A_delay*P0_static*A_delay'+Q_delay; % Covariance matrice estimation

    Kg=P_pre*H_delay'*inv(H_delay*P_pre*H_delay'+R_delay); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H_delay*X_pre); % State estimation update
    Covariance_matrice=(I_delay-Kg*H_delay)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;

== matlab function e2_3_kalman_filtre_2017/CMD/CMD5/Subsystem/MATLAB Function ==
function [x5_, y5_, z5_] = fcn(timestamp, sim_end_time, a, b, k, bb, w1, w2,tb2, tb3, tb4,tb5, tb6, tb7, tb8)
persistent time_start;
if isempty(time_start)
     time_start = timestamp;
end

if (timestamp - time_start) < 2
    t = 0;
elseif (sim_end_time - timestamp) >=2
    t = timestamp - 2;
else
    t = sim_end_time - 4;
end
    x5_ = a*sin(w1*(t -tb5));
    y5_ = b*cos(w2*(t -tb5));
    z5_= k*y5_+bb;

== matlab function e2_3_kalman_filtre_2017/CMD/CMD6/Subsystem/MATLAB Function ==
function [x6_, y6_, z6_] = fcn(timestamp, sim_end_time, a, b, k, bb, w1, w2,tb2, tb3, tb4,tb5, tb6, tb7, tb8)
persistent time_start;
if isempty(time_start)
     time_start = timestamp;
end

if (timestamp - time_start) < 2
    t = 0;
elseif (sim_end_time - timestamp) >=2
    t = timestamp - 2;
else
    t = sim_end_time - 4;
end
    x6_ = a*sin(w1*(t -tb6));
    y6_ = b*cos(w2*(t -tb6));
    z6_= k*y6_+bb;

== matlab function e2_3_kalman_filtre_2017/CMD/CMD7/Subsystem/MATLAB Function ==
function [x7_, y7_, z7_] = fcn(timestamp, sim_end_time, a, b, k, bb, w1, w2,tb2, tb3, tb4,tb5, tb6, tb7, tb8)
persistent time_start;
if isempty(time_start)
     time_start = timestamp;
end

if (timestamp - time_start) < 2
    t = 0;
elseif (sim_end_time - timestamp) >=2
    t = timestamp - 2;
else
    t = sim_end_time - 4;
end
    x7_ = a*sin(w1*(t -tb7));
    y7_ = b*cos(w2*(t -tb7));
    z7_= k*y7_+bb;

== matlab function e2_3_kalman_filtre_2017/CMD/CMD8/Subsystem/MATLAB Function ==
function [x8_, y8_, z8_] = fcn(timestamp, sim_end_time, a, b, k, bb, w1, w2,tb2, tb3, tb4,tb5, tb6, tb7, tb8)
persistent time_start;
if isempty(time_start)
     time_start = timestamp;
end

if (timestamp - time_start) < 2
    t = 0;
elseif (sim_end_time - timestamp) >=2
    t = timestamp - 2;
else
    t = sim_end_time - 4;
end
    x8_ = a*sin(w1*(t -tb8));
    y8_ = b*cos(w2*(t -tb8));
    z8_= k*y8_+bb;

== matlab function e2_3_kalman_filtre_2017/control system/Baseline Controller Basic/Decoupling/MATLAB Function ==
function y = fcn(u,a)
y = satgd(u,a);

== matlab function e2_3_kalman_filtre_2017/control system/Baseline Controller Basic/Decoupling/Coordinate trnasformation 
from inertial frame to body frame  ==
function Vec_xy  = fcn(Vec_i , psi)
%#codegen
T = [cos(psi) sin(psi) ; -sin(psi) cos(psi)] ; 
Vec_xy = T*Vec_i(1:2,1);

== matlab function e2_3_kalman_filtre_2017/control system/Kalman_Filtre/Kalman Filtre Psi/Kalman Filtre for getting the velocity Psi ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity) % Mesurement_State

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
    P0_static=[[0.1,0 0;0,0.1,0;0 0 0.1] zeros(3) zeros(3) ;zeros(3) [0.1,0 0;0,0.1,0;0 0 0.1] zeros(3);zeros(3) zeros(3) [0.1,0 0;0,0.1,0;0 0 0.1]]; % the initilized matrice of estimated error
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0;0;0;0;0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.01;

% Process Noise
p_var =0.05; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise
Q_delay=[Q zeros(3) zeros(3);zeros(3) Q zeros(3);zeros(3) zeros(3) Q];
% Mesurement Noise
m_var = 0.01; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise
R_delay=R;
V_delay=R_delay*randn;
% Observation matrice
H=[1 0 0];
H_delay=[0 0 0 0 0 0 H];
% The indentity matrice
I=eye(3); 
I_delay=eye(9);

A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];
A_delay=[A zeros(3) zeros(3);zeros(3) A zeros(3); zeros(3) zeros(3) A];
% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% X_real_static=X_real;    
% Mesurement_Velocity=H_delay*(Mesurement_State)+V_delay;

%   Kalman Update process
    X_pre=A_delay*Xkf_static; % State estimation
    P_pre=A_delay*P0_static*A_delay'+Q_delay; % Covariance matrice estimation

    Kg=P_pre*H_delay'*inv(H_delay*P_pre*H_delay'+R_delay); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H_delay*X_pre); % State estimation update
    Covariance_matrice=(I_delay-Kg*H_delay)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;

== matlab function e2_3_kalman_filtre_2017/control system/Kalman_Filtre/Kalman Filtre Psi/Kalman Filtre Psi/Kalman Filtre for getting the velocity Psi ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity)

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
    P0_static=[0.1,0 0;0,0.1,0;0 0 0.1]; % the initilized matrice of estimated error
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.01;

% Process Noise
p_var =0.01; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise

% Mesurement Noise
m_var = 0.05; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise

% Observation matrice
H=[1 0 0];

% The indentity matrice
I=eye(3); 

% State Transition Martrix
A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];


% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% Mesurement_Velocity=H*(X_real)+V;
% X_real_static=X_real;    

%   Kalman Update process
    X_pre=A*Xkf_static; % State estimation
    P_pre=A*P0_static*A'+Q; % Covariance matrice estimation

    Kg=P_pre*H'*inv(H*P_pre*H'+R); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H*X_pre); % State estimation update
    Covariance_matrice=(I-Kg*H)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;

== matlab function e2_3_kalman_filtre_2017/CMD/CMD2/MATLAB Function ==
function [x_d_, y_d_, z_d_] = fcn(x_d, y_d, z_d, timestamp, x,y,z,battery_status, sim_time_end,battery_threshold, z_d_for_land, UAV_NUM)
persistent s_x s_y s_z ready_land
if isempty(s_x)
    s_x = x;
end
if isempty(s_y)
    s_y = y;
end
if isempty(s_z)
    s_z = z;
end
if isempty(ready_land)
    ready_land = false;
end
    
battery_low = false;
for i = 1:UAV_NUM
    if battery_status(i) < battery_threshold
        battery_low = true;
        break;
    end
end
if sim_time_end - timestamp < 1
    tello_stop = true;
else
    tello_stop = false;
end
if battery_low || tello_stop
    if ~ready_land
        s_x = x;
        s_y = y;
        ready_land = true;
    end
    z_d_ = z_d_for_land;
    x_d_ = s_x;
    y_d_ = s_y;
else
   ready_land = false;
   s_x = x;
   s_y = y;
   x_d_ = x_d;
   y_d_ = y_d;
   z_d_ = z_d;
end

== matlab function e2_3_kalman_filtre_2017/control system/Kalman_Filtre/Kalman Filtre X/Kalman Filtre X/Kalman Filtre for getting the velocity X ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity)

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
    P0_static=[0.1,0 0;0,0.1,0;0 0 0.1]; % the initilized matrice of estimated error
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.01;

% Process Noise
p_var =0.05; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise

% Mesurement Noise
m_var = 0.01; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise

% Observation matrice
H=[1 0 0];

% The indentity matrice
I=eye(3); 

% State Transition Martrix
A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];

% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% Mesurement_Velocity=H*(X_real)+V;
% X_real_static=X_real;    

%   Kalman Update process
    X_pre=A*Xkf_static; % State estimation
    P_pre=A*P0_static*A'+Q; % Covariance matrice estimation

    Kg=P_pre*H'*inv(H*P_pre*H'+R); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H*X_pre); % State estimation update
    Covariance_matrice=(I-Kg*H)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;

== matlab function e2_3_kalman_filtre_2017/CMD/CMD3/MATLAB Function ==
function [x_d_, y_d_, z_d_] = fcn(x_d, y_d, z_d, timestamp, x,y,z,battery_status, sim_time_end,battery_threshold, z_d_for_land, UAV_NUM)
persistent s_x s_y s_z ready_land
if isempty(s_x)
    s_x = x;
end
if isempty(s_y)
    s_y = y;
end
if isempty(s_z)
    s_z = z;
end
if isempty(ready_land)
    ready_land = false;
end
    
battery_low = false;
for i = 1:UAV_NUM
    if battery_status(i) < battery_threshold
        battery_low = true;
        break;
    end
end
if sim_time_end - timestamp < 1
    tello_stop = true;
else
    tello_stop = false;
end
if battery_low || tello_stop
    if ~ready_land
        s_x = x;
        s_y = y;
        ready_land = true;
    end
    z_d_ = z_d_for_land;
    x_d_ = s_x;
    y_d_ = s_y;
else
   ready_land = false;
   s_x = x;
   s_y = y;
   x_d_ = x_d;
   y_d_ = y_d;
   z_d_ = z_d;
end

== matlab function e2_3_kalman_filtre_2017/CMD/CMD3/Subsystem1/MATLAB Function ==
function [x3_, y3_, z3_] = fcn(timestamp, sim_end_time, a, b, k, bb, w1, w2,tb2, tb3, tb4)
persistent time_start;
if isempty(time_start)
     time_start = timestamp;
end

if (timestamp - time_start) < 2
    t = 0;
elseif (sim_end_time - timestamp) >=2
    t = timestamp - 2;
else
    t = sim_end_time - 4;
end
    x3_ = a*sin(w1*(t - tb3));
    y3_ = b*cos(w2*(t - tb3));
    z3_ = k*y3_+bb;

== matlab function e2_3_kalman_filtre_2017/control system/Kalman_Filtre/Kalman Filtre X/Kalman Filtre for getting the velocity X ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity) % Mesurement_State

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
    P0_static=[[0.1,0 0;0,0.1,0;0 0 0.1] zeros(3) zeros(3) ;zeros(3) [0.1,0 0;0,0.1,0;0 0 0.1] zeros(3);zeros(3) zeros(3) [0.1,0 0;0,0.1,0;0 0 0.1]]; % the initilized matrice of estimated error
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0;0;0;0;0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.025;

% Process Noise
p_var =3; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise
Q_delay=[Q zeros(3) zeros(3);zeros(3) Q zeros(3);zeros(3) zeros(3) Q];
% Mesurement Noise
m_var =0.05; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise
R_delay=R;
V_delay=R_delay*randn;
% Observation matrice
H=[1 0 0];
H_delay=[0 0 0 0 0 0 H];
% The indentity matrice
I=eye(3); 
I_delay=eye(9);

A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];
A_delay=[A zeros(3) zeros(3);zeros(3) A zeros(3); zeros(3) zeros(3) A];
% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% X_real_static=X_real;    
% Mesurement_Velocity=H_delay*(Mesurement_State)+V_delay;

%   Kalman Update process
    X_pre=A_delay*Xkf_static; % State estimation
    P_pre=A_delay*P0_static*A_delay'+Q_delay; % Covariance matrice estimation

    Kg=P_pre*H_delay'*inv(H_delay*P_pre*H_delay'+R_delay); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H_delay*X_pre); % State estimation update
    Covariance_matrice=(I_delay-Kg*H_delay)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;

== matlab function e2_3_kalman_filtre_2017/control system/Kalman_Filtre/Kalman Filtre Y/Kalman Filtre Y/Kalman Filtre for getting the velocity Y ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity)

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
    P0_static=[0.1,0 0;0,0.1,0;0 0 0.1]; % the initilized matrice of estimated error
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.01;

% Process Noise
p_var =0.05; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise

% Mesurement Noise
m_var =0.01; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise

% Observation matrice
H=[1 0 0];

% The indentity matrice
I=eye(3); 

% State Transition Martrix
A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];

% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% Mesurement_Velocity=H*(X_real)+V;
% X_real_static=X_real;    

%   Kalman Update process
    X_pre=A*Xkf_static; % State estimation
    P_pre=A*P0_static*A'+Q; % Covariance matrice estimation

    Kg=P_pre*H'*inv(H*P_pre*H'+R); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H*X_pre); % State estimation update
    Covariance_matrice=(I-Kg*H)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;

== matlab function e2_3_kalman_filtre_2017/control system/Kalman_Filtre/Kalman Filtre Y/Kalman Filtre for getting the velocity Y ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity) % Mesurement_State

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
       P0_static=[[0.1,0 0;0,0.1,0;0 0 0.1] zeros(3) zeros(3) ;zeros(3) [0.1,0 0;0,0.1,0;0 0 0.1] zeros(3);zeros(3) zeros(3) [0.1,0 0;0,0.1,0;0 0 0.1]]; % the initilized matrice of estimated error 
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0;0;0;0;0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.025;

% Process Noise
p_var =3; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise
Q_delay=[Q zeros(3) zeros(3);zeros(3) Q zeros(3);zeros(3) zeros(3) Q];
% Mesurement Noise
m_var = 0.05; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise
R_delay=R;
V_delay=R_delay*randn;
% Observation matrice
H=[1 0 0];
H_delay=[0 0 0 0 0 0 H];
% The indentity matrice
I=eye(3); 
I_delay=eye(9);

A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];
A_delay=[A zeros(3) zeros(3);zeros(3) A zeros(3); zeros(3) zeros(3) A];
% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% X_real_static=X_real;    
% Mesurement_Velocity=H_delay*(Mesurement_State)+V_delay;

%   Kalman Update process
    X_pre=A_delay*Xkf_static; % State estimation
    P_pre=A_delay*P0_static*A_delay'+Q_delay; % Covariance matrice estimation

    Kg=P_pre*H_delay'*inv(H_delay*P_pre*H_delay'+R_delay); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H_delay*X_pre); % State estimation update
    Covariance_matrice=(I_delay-Kg*H_delay)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;

== matlab function e2_3_kalman_filtre_2017/control system/Baseline Controller3/MATLAB Function ==
function y = fcn(u,a)
y = satgd(u,a);

== matlab function e2_3_kalman_filtre_2017/control system/Baseline Controller3/Position controller/Coordinate trnasformation 
from inertial frame to body frame  ==
function Vec_xy  = fcn(Vec_i , psi)
%#codegen
T = [cos(psi) sin(psi) ; -sin(psi) cos(psi)] ; 
Vec_xy = T*Vec_i(1:2,1);

== matlab function e2_3_kalman_filtre_2017/control system/Baseline Controller4/MATLAB Function ==
function y = fcn(u,a)
y = satgd(u,a);

== matlab function e2_3_kalman_filtre_2017/control system/Baseline Controller4/Position controller/Coordinate trnasformation 
from inertial frame to body frame  ==
function Vec_xy  = fcn(Vec_i , psi)
%#codegen
T = [cos(psi) sin(psi) ; -sin(psi) cos(psi)] ; 
Vec_xy = T*Vec_i(1:2,1);

== matlab function e2_3_kalman_filtre_2017/control system/Baseline Controller5/MATLAB Function ==
function y = fcn(u,a)
y = satgd(u,a);

== matlab function e2_3_kalman_filtre_2017/control system/Baseline Controller5/Position controller/Coordinate trnasformation 
from inertial frame to body frame  ==
function Vec_xy  = fcn(Vec_i , psi)
%#codegen
T = [cos(psi) sin(psi) ; -sin(psi) cos(psi)] ; 
Vec_xy = T*Vec_i(1:2,1);

== matlab function e2_3_kalman_filtre_2017/control system/Baseline Controller6/MATLAB Function ==
function y = fcn(u,a)
y = satgd(u,a);

== matlab function e2_3_kalman_filtre_2017/control system/Baseline Controller6/Position controller/Coordinate trnasformation 
from inertial frame to body frame  ==
function Vec_xy  = fcn(Vec_i , psi)
%#codegen
T = [cos(psi) sin(psi) ; -sin(psi) cos(psi)] ; 
Vec_xy = T*Vec_i(1:2,1);

== matlab function e2_3_kalman_filtre_2017/control system/Baseline Controller7/MATLAB Function ==
function y = fcn(u,a)
y = satgd(u,a);

== matlab function e2_3_kalman_filtre_2017/control system/Baseline Controller7/Position controller/Coordinate trnasformation 
from inertial frame to body frame  ==
function Vec_xy  = fcn(Vec_i , psi)
%#codegen
T = [cos(psi) sin(psi) ; -sin(psi) cos(psi)] ; 
Vec_xy = T*Vec_i(1:2,1);

== matlab function e2_3_kalman_filtre_2017/control system/Baseline Controller8/MATLAB Function ==
function y = fcn(u,a)
y = satgd(u,a);

== matlab function e2_3_kalman_filtre_2017/control system/Baseline Controller8/Position controller/Coordinate trnasformation 
from inertial frame to body frame  ==
function Vec_xy  = fcn(Vec_i , psi)
%#codegen
T = [cos(psi) sin(psi) ; -sin(psi) cos(psi)] ; 
Vec_xy = T*Vec_i(1:2,1);
