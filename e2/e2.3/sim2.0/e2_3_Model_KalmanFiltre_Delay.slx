simulink model "e2_3_Model_KalmanFiltre_Delay"  (R2019b)
settings: Solver=ode4  StartTime=0.0  StopTime=100  FixedStep=sampleTime  RelTol=1e-3  EnableMultiTasking=on
values from neighbouring files (symbols this model uses):
  k_d_x = 0.7    [startSimulation.m]
  k_d_y = 0.7    [startSimulation.m]
  k_d_yaw = 0.05    [startSimulation.m]
  k_d_z = 0.05    [startSimulation.m]
  k_i_x = 0.01    [startSimulation.m]
  k_i_y = 0.01    [startSimulation.m]
  k_i_yaw = 0.01    [startSimulation.m]
  k_i_z = 0.01    [startSimulation.m]
  k_p_x = 1    [startSimulation.m]
  k_p_y = 1    [startSimulation.m]
  k_p_yaw = 2    [startSimulation.m]
  k_p_z = 3    [startSimulation.m]
  Kd_RP_AgngleRate = 0.005    [startSimulation.m]
  Kd_YAW_AngleRate = 0.05    [startSimulation.m]
  Ki_RP_AgngleRate = 0.01    [startSimulation.m]
  Ki_YAW_AngleRate = 0.8    [startSimulation.m]
  Kp_RP_AgngleRate = 0.55    [startSimulation.m]
  Kp_RP_ANGLE = 6.5    [startSimulation.m]
  Kp_YAW_AngleRate = 3.2    [startSimulation.m]
  saturation_psi = 2    [startSimulation.m]
  saturation_x = 2    [startSimulation.m]
  saturation_y = 2    [startSimulation.m]
  saturation_z = 2    [startSimulation.m]
  simDT = 0.01    [startSimulation.m]
undefined symbols (not defined in the file or in its folder): DiscIntNeverNeededParam, Earth, earthRadius, KiPitchAttitude, KiRollAttitude, ModelInit, ModelParam, Receive, Send, sigbuilder_block, unidrnd, V2, WGS84, WMM2015
libraries: simulink x26, sharedtransform x3, aerolibtransform2 x3, aerolibfltsims x3, aerolibutil x2, aerolibanimutils x1, shared6dof x1, aerolibatmos2 x1, aerolibconvert2 x1, aerolibobsolete x1, aerolibasang x1, aerolibnav x1
(part 3 of 3)

== matlab function e2_3_Model_KalmanFiltre_Delay/Model/Kalman Filtre Psi/Kalman Filtre Psi/Kalman Filtre for getting the velocity Psi ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity)

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
    P0_static=[0.1,0 0;0,0.1,0;0 0 0.1]; % the initilized matrice of estimated error
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.01;

% Process Noise
p_var =0.01; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise

% Mesurement Noise
m_var = 0.05; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise

% Observation matrice
H=[1 0 0];

% The indentity matrice
I=eye(3); 

% State Transition Martrix
A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];


% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% Mesurement_Velocity=H*(X_real)+V;
% X_real_static=X_real;    

%   Kalman Update process
    X_pre=A*Xkf_static; % State estimation
    P_pre=A*P0_static*A'+Q; % Covariance matrice estimation

    Kg=P_pre*H'*inv(H*P_pre*H'+R); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H*X_pre); % State estimation update
    Covariance_matrice=(I-Kg*H)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;

== matlab function e2_3_Model_KalmanFiltre_Delay/Model/Kalman Filtre X/Kalman Filtre X/Kalman Filtre for getting the velocity X ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity)

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
    P0_static=[0.1,0 0;0,0.1,0;0 0 0.1]; % the initilized matrice of estimated error
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.01;

% Process Noise
p_var =0.05; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise

% Mesurement Noise
m_var = 0.01; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise

% Observation matrice
H=[1 0 0];

% The indentity matrice
I=eye(3); 

% State Transition Martrix
A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];

% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% Mesurement_Velocity=H*(X_real)+V;
% X_real_static=X_real;    

%   Kalman Update process
    X_pre=A*Xkf_static; % State estimation
    P_pre=A*P0_static*A'+Q; % Covariance matrice estimation

    Kg=P_pre*H'*inv(H*P_pre*H'+R); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H*X_pre); % State estimation update
    Covariance_matrice=(I-Kg*H)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;

== matlab function e2_3_Model_KalmanFiltre_Delay/Model/Kalman Filtre Y/Kalman Filtre Y/Kalman Filtre for getting the velocity Y ==
function [Covariance_matrice,X_Kalmanfiltred] = fcn(Mesurement_Velocity)

% Persistent process for saving the last state and initilizing the variable
persistent P0_static;
if isempty(P0_static)
    P0_static=[0.1,0 0;0,0.1,0;0 0 0.1]; % the initilized matrice of estimated error
end

persistent Xkf_static;
if isempty(Xkf_static)
    Xkf_static=[0;0;0]; % the initilized state from Kalman Estimaton
end

% Determine the constants

% Simple time
Ts =0.01;

% Process Noise
p_var =0.05; % sigma
Q = eye(3)*p_var^2; % the covariance matrice of process noise
W=Q*randn(3,1);  % process noise

% Mesurement Noise
m_var =0.01; % sigma
R = [m_var^2 ];  % the covariance matrice of mesurement noise
V=R*randn; % mesurement noise

% Observation matrice
H=[1 0 0];

% The indentity matrice
I=eye(3); 

% State Transition Martrix
A=[1 Ts 0.5*(Ts^2);0 1 Ts;0 0 1];

% Steady-State equation

% persistent X_real_static;
% if isempty(X_real_static)
%     X_real_static=[0;0]; % the initilized state from Kalman Estimaton
% end
% X_real_forward=X_real_static;
% X_real=A*X_real_forward+W;
% Mesurement_Velocity=H*(X_real)+V;
% X_real_static=X_real;    

%   Kalman Update process
    X_pre=A*Xkf_static; % State estimation
    P_pre=A*P0_static*A'+Q; % Covariance matrice estimation

    Kg=P_pre*H'*inv(H*P_pre*H'+R); % Kalman Gain calculation

    X_Kalmanfiltred=X_pre+Kg*(Mesurement_Velocity-H*X_pre); % State estimation update
    Covariance_matrice=(I-Kg*H)*P_pre; % Covariance matrice estimation update

% update the value of the persistent variable for iterating the Kalman process
P0_static=Covariance_matrice;
Xkf_static=X_Kalmanfiltred;
